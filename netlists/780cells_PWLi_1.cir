*Auto-gererated 780-cell delay line circuit

I1 1 0 PWL file="C:\Users\zOob\Documents\SB REU\LTspice\data\PWL_Current_1.txt"
C2 1 0 6.8p Cpar = 0
L1 1 2 290n
R1 2 3 0.17
C3 3 0 6.8p Cpar = 0
L2 3 4 290n
R2 4 5 0.17
C4 5 0 6.8p Cpar = 0
L3 5 6 290n
R3 6 7 0.17
C5 7 0 6.8p Cpar = 0
L4 7 8 290n
R4 8 9 0.17
C6 9 0 6.8p Cpar = 0
L5 9 10 290n
R5 10 11 0.17
C7 11 0 6.8p Cpar = 0
L6 11 12 290n
R6 12 13 0.17
C8 13 0 6.8p Cpar = 0
L7 13 14 290n
R7 14 15 0.17
C9 15 0 6.8p Cpar = 0
L8 15 16 290n
R8 16 17 0.17
C10 17 0 6.8p Cpar = 0
L9 17 18 290n
R9 18 19 0.17
C11 19 0 6.8p Cpar = 0
L10 19 20 290n
R10 20 21 0.17
C12 21 0 6.8p Cpar = 0
L11 21 22 290n
R11 22 23 0.17
C13 23 0 6.8p Cpar = 0
L12 23 24 290n
R12 24 25 0.17
C14 25 0 6.8p Cpar = 0
L13 25 26 290n
R13 26 27 0.17
C15 27 0 6.8p Cpar = 0
L14 27 28 290n
R14 28 29 0.17
C16 29 0 6.8p Cpar = 0
L15 29 30 290n
R15 30 31 0.17
C17 31 0 6.8p Cpar = 0
L16 31 32 290n
R16 32 33 0.17
C18 33 0 6.8p Cpar = 0
L17 33 34 290n
R17 34 35 0.17
C19 35 0 6.8p Cpar = 0
L18 35 36 290n
R18 36 37 0.17
C20 37 0 6.8p Cpar = 0
L19 37 38 290n
R19 38 39 0.17
C21 39 0 6.8p Cpar = 0
L20 39 40 290n
R20 40 41 0.17
C22 41 0 6.8p Cpar = 0
L21 41 42 290n
R21 42 43 0.17
C23 43 0 6.8p Cpar = 0
L22 43 44 290n
R22 44 45 0.17
C24 45 0 6.8p Cpar = 0
L23 45 46 290n
R23 46 47 0.17
C25 47 0 6.8p Cpar = 0
L24 47 48 290n
R24 48 49 0.17
C26 49 0 6.8p Cpar = 0
L25 49 50 290n
R25 50 51 0.17
C27 51 0 6.8p Cpar = 0
L26 51 52 290n
R26 52 53 0.17
C28 53 0 6.8p Cpar = 0
L27 53 54 290n
R27 54 55 0.17
C29 55 0 6.8p Cpar = 0
L28 55 56 290n
R28 56 57 0.17
C30 57 0 6.8p Cpar = 0
L29 57 58 290n
R29 58 59 0.17
C31 59 0 6.8p Cpar = 0
L30 59 60 290n
R30 60 61 0.17
C32 61 0 6.8p Cpar = 0
L31 61 62 290n
R31 62 63 0.17
C33 63 0 6.8p Cpar = 0
L32 63 64 290n
R32 64 65 0.17
C34 65 0 6.8p Cpar = 0
L33 65 66 290n
R33 66 67 0.17
C35 67 0 6.8p Cpar = 0
L34 67 68 290n
R34 68 69 0.17
C36 69 0 6.8p Cpar = 0
L35 69 70 290n
R35 70 71 0.17
C37 71 0 6.8p Cpar = 0
L36 71 72 290n
R36 72 73 0.17
C38 73 0 6.8p Cpar = 0
L37 73 74 290n
R37 74 75 0.17
C39 75 0 6.8p Cpar = 0
L38 75 76 290n
R38 76 77 0.17
C40 77 0 6.8p Cpar = 0
L39 77 78 290n
R39 78 79 0.17
C41 79 0 6.8p Cpar = 0
L40 79 80 290n
R40 80 81 0.17
C42 81 0 6.8p Cpar = 0
L41 81 82 290n
R41 82 83 0.17
C43 83 0 6.8p Cpar = 0
L42 83 84 290n
R42 84 85 0.17
C44 85 0 6.8p Cpar = 0
L43 85 86 290n
R43 86 87 0.17
C45 87 0 6.8p Cpar = 0
L44 87 88 290n
R44 88 89 0.17
C46 89 0 6.8p Cpar = 0
L45 89 90 290n
R45 90 91 0.17
C47 91 0 6.8p Cpar = 0
L46 91 92 290n
R46 92 93 0.17
C48 93 0 6.8p Cpar = 0
L47 93 94 290n
R47 94 95 0.17
C49 95 0 6.8p Cpar = 0
L48 95 96 290n
R48 96 97 0.17
C50 97 0 6.8p Cpar = 0
L49 97 98 290n
R49 98 99 0.17
C51 99 0 6.8p Cpar = 0
L50 99 100 290n
R50 100 101 0.17
C52 101 0 6.8p Cpar = 0
L51 101 102 290n
R51 102 103 0.17
C53 103 0 6.8p Cpar = 0
L52 103 104 290n
R52 104 105 0.17
C54 105 0 6.8p Cpar = 0
L53 105 106 290n
R53 106 107 0.17
C55 107 0 6.8p Cpar = 0
L54 107 108 290n
R54 108 109 0.17
C56 109 0 6.8p Cpar = 0
L55 109 110 290n
R55 110 111 0.17
C57 111 0 6.8p Cpar = 0
L56 111 112 290n
R56 112 113 0.17
C58 113 0 6.8p Cpar = 0
L57 113 114 290n
R57 114 115 0.17
C59 115 0 6.8p Cpar = 0
L58 115 116 290n
R58 116 117 0.17
C60 117 0 6.8p Cpar = 0
L59 117 118 290n
R59 118 119 0.17
C61 119 0 6.8p Cpar = 0
L60 119 120 290n
R60 120 121 0.17
C62 121 0 6.8p Cpar = 0
L61 121 122 290n
R61 122 123 0.17
C63 123 0 6.8p Cpar = 0
L62 123 124 290n
R62 124 125 0.17
C64 125 0 6.8p Cpar = 0
L63 125 126 290n
R63 126 127 0.17
C65 127 0 6.8p Cpar = 0
L64 127 128 290n
R64 128 129 0.17
C66 129 0 6.8p Cpar = 0
L65 129 130 290n
R65 130 131 0.17
C67 131 0 6.8p Cpar = 0
L66 131 132 290n
R66 132 133 0.17
C68 133 0 6.8p Cpar = 0
L67 133 134 290n
R67 134 135 0.17
C69 135 0 6.8p Cpar = 0
L68 135 136 290n
R68 136 137 0.17
C70 137 0 6.8p Cpar = 0
L69 137 138 290n
R69 138 139 0.17
C71 139 0 6.8p Cpar = 0
L70 139 140 290n
R70 140 141 0.17
C72 141 0 6.8p Cpar = 0
L71 141 142 290n
R71 142 143 0.17
C73 143 0 6.8p Cpar = 0
L72 143 144 290n
R72 144 145 0.17
C74 145 0 6.8p Cpar = 0
L73 145 146 290n
R73 146 147 0.17
C75 147 0 6.8p Cpar = 0
L74 147 148 290n
R74 148 149 0.17
C76 149 0 6.8p Cpar = 0
L75 149 150 290n
R75 150 151 0.17
C77 151 0 6.8p Cpar = 0
L76 151 152 290n
R76 152 153 0.17
C78 153 0 6.8p Cpar = 0
L77 153 154 290n
R77 154 155 0.17
C79 155 0 6.8p Cpar = 0
L78 155 156 290n
R78 156 157 0.17
C80 157 0 6.8p Cpar = 0
L79 157 158 290n
R79 158 159 0.17
C81 159 0 6.8p Cpar = 0
L80 159 160 290n
R80 160 161 0.17
C82 161 0 6.8p Cpar = 0
L81 161 162 290n
R81 162 163 0.17
C83 163 0 6.8p Cpar = 0
L82 163 164 290n
R82 164 165 0.17
C84 165 0 6.8p Cpar = 0
L83 165 166 290n
R83 166 167 0.17
C85 167 0 6.8p Cpar = 0
L84 167 168 290n
R84 168 169 0.17
C86 169 0 6.8p Cpar = 0
L85 169 170 290n
R85 170 171 0.17
C87 171 0 6.8p Cpar = 0
L86 171 172 290n
R86 172 173 0.17
C88 173 0 6.8p Cpar = 0
L87 173 174 290n
R87 174 175 0.17
C89 175 0 6.8p Cpar = 0
L88 175 176 290n
R88 176 177 0.17
C90 177 0 6.8p Cpar = 0
L89 177 178 290n
R89 178 179 0.17
C91 179 0 6.8p Cpar = 0
L90 179 180 290n
R90 180 181 0.17
C92 181 0 6.8p Cpar = 0
L91 181 182 290n
R91 182 183 0.17
C93 183 0 6.8p Cpar = 0
L92 183 184 290n
R92 184 185 0.17
C94 185 0 6.8p Cpar = 0
L93 185 186 290n
R93 186 187 0.17
C95 187 0 6.8p Cpar = 0
L94 187 188 290n
R94 188 189 0.17
C96 189 0 6.8p Cpar = 0
L95 189 190 290n
R95 190 191 0.17
C97 191 0 6.8p Cpar = 0
L96 191 192 290n
R96 192 193 0.17
C98 193 0 6.8p Cpar = 0
L97 193 194 290n
R97 194 195 0.17
C99 195 0 6.8p Cpar = 0
L98 195 196 290n
R98 196 197 0.17
C100 197 0 6.8p Cpar = 0
L99 197 198 290n
R99 198 199 0.17
C101 199 0 6.8p Cpar = 0
L100 199 200 290n
R100 200 201 0.17
C102 201 0 6.8p Cpar = 0
L101 201 202 290n
R101 202 203 0.17
C103 203 0 6.8p Cpar = 0
L102 203 204 290n
R102 204 205 0.17
C104 205 0 6.8p Cpar = 0
L103 205 206 290n
R103 206 207 0.17
C105 207 0 6.8p Cpar = 0
L104 207 208 290n
R104 208 209 0.17
C106 209 0 6.8p Cpar = 0
L105 209 210 290n
R105 210 211 0.17
C107 211 0 6.8p Cpar = 0
L106 211 212 290n
R106 212 213 0.17
C108 213 0 6.8p Cpar = 0
L107 213 214 290n
R107 214 215 0.17
C109 215 0 6.8p Cpar = 0
L108 215 216 290n
R108 216 217 0.17
C110 217 0 6.8p Cpar = 0
L109 217 218 290n
R109 218 219 0.17
C111 219 0 6.8p Cpar = 0
L110 219 220 290n
R110 220 221 0.17
C112 221 0 6.8p Cpar = 0
L111 221 222 290n
R111 222 223 0.17
C113 223 0 6.8p Cpar = 0
L112 223 224 290n
R112 224 225 0.17
C114 225 0 6.8p Cpar = 0
L113 225 226 290n
R113 226 227 0.17
C115 227 0 6.8p Cpar = 0
L114 227 228 290n
R114 228 229 0.17
C116 229 0 6.8p Cpar = 0
L115 229 230 290n
R115 230 231 0.17
C117 231 0 6.8p Cpar = 0
L116 231 232 290n
R116 232 233 0.17
C118 233 0 6.8p Cpar = 0
L117 233 234 290n
R117 234 235 0.17
C119 235 0 6.8p Cpar = 0
L118 235 236 290n
R118 236 237 0.17
C120 237 0 6.8p Cpar = 0
L119 237 238 290n
R119 238 239 0.17
C121 239 0 6.8p Cpar = 0
L120 239 240 290n
R120 240 241 0.17
C122 241 0 6.8p Cpar = 0
L121 241 242 290n
R121 242 243 0.17
C123 243 0 6.8p Cpar = 0
L122 243 244 290n
R122 244 245 0.17
C124 245 0 6.8p Cpar = 0
L123 245 246 290n
R123 246 247 0.17
C125 247 0 6.8p Cpar = 0
L124 247 248 290n
R124 248 249 0.17
C126 249 0 6.8p Cpar = 0
L125 249 250 290n
R125 250 251 0.17
C127 251 0 6.8p Cpar = 0
L126 251 252 290n
R126 252 253 0.17
C128 253 0 6.8p Cpar = 0
L127 253 254 290n
R127 254 255 0.17
C129 255 0 6.8p Cpar = 0
L128 255 256 290n
R128 256 257 0.17
C130 257 0 6.8p Cpar = 0
L129 257 258 290n
R129 258 259 0.17
C131 259 0 6.8p Cpar = 0
L130 259 260 290n
R130 260 261 0.17
C132 261 0 6.8p Cpar = 0
L131 261 262 290n
R131 262 263 0.17
C133 263 0 6.8p Cpar = 0
L132 263 264 290n
R132 264 265 0.17
C134 265 0 6.8p Cpar = 0
L133 265 266 290n
R133 266 267 0.17
C135 267 0 6.8p Cpar = 0
L134 267 268 290n
R134 268 269 0.17
C136 269 0 6.8p Cpar = 0
L135 269 270 290n
R135 270 271 0.17
C137 271 0 6.8p Cpar = 0
L136 271 272 290n
R136 272 273 0.17
C138 273 0 6.8p Cpar = 0
L137 273 274 290n
R137 274 275 0.17
C139 275 0 6.8p Cpar = 0
L138 275 276 290n
R138 276 277 0.17
C140 277 0 6.8p Cpar = 0
L139 277 278 290n
R139 278 279 0.17
C141 279 0 6.8p Cpar = 0
L140 279 280 290n
R140 280 281 0.17
C142 281 0 6.8p Cpar = 0
L141 281 282 290n
R141 282 283 0.17
C143 283 0 6.8p Cpar = 0
L142 283 284 290n
R142 284 285 0.17
C144 285 0 6.8p Cpar = 0
L143 285 286 290n
R143 286 287 0.17
C145 287 0 6.8p Cpar = 0
L144 287 288 290n
R144 288 289 0.17
C146 289 0 6.8p Cpar = 0
L145 289 290 290n
R145 290 291 0.17
C147 291 0 6.8p Cpar = 0
L146 291 292 290n
R146 292 293 0.17
C148 293 0 6.8p Cpar = 0
L147 293 294 290n
R147 294 295 0.17
C149 295 0 6.8p Cpar = 0
L148 295 296 290n
R148 296 297 0.17
C150 297 0 6.8p Cpar = 0
L149 297 298 290n
R149 298 299 0.17
C151 299 0 6.8p Cpar = 0
L150 299 300 290n
R150 300 301 0.17
C152 301 0 6.8p Cpar = 0
L151 301 302 290n
R151 302 303 0.17
C153 303 0 6.8p Cpar = 0
L152 303 304 290n
R152 304 305 0.17
C154 305 0 6.8p Cpar = 0
L153 305 306 290n
R153 306 307 0.17
C155 307 0 6.8p Cpar = 0
L154 307 308 290n
R154 308 309 0.17
C156 309 0 6.8p Cpar = 0
L155 309 310 290n
R155 310 311 0.17
C157 311 0 6.8p Cpar = 0
L156 311 312 290n
R156 312 313 0.17
C158 313 0 6.8p Cpar = 0
L157 313 314 290n
R157 314 315 0.17
C159 315 0 6.8p Cpar = 0
L158 315 316 290n
R158 316 317 0.17
C160 317 0 6.8p Cpar = 0
L159 317 318 290n
R159 318 319 0.17
C161 319 0 6.8p Cpar = 0
L160 319 320 290n
R160 320 321 0.17
C162 321 0 6.8p Cpar = 0
L161 321 322 290n
R161 322 323 0.17
C163 323 0 6.8p Cpar = 0
L162 323 324 290n
R162 324 325 0.17
C164 325 0 6.8p Cpar = 0
L163 325 326 290n
R163 326 327 0.17
C165 327 0 6.8p Cpar = 0
L164 327 328 290n
R164 328 329 0.17
C166 329 0 6.8p Cpar = 0
L165 329 330 290n
R165 330 331 0.17
C167 331 0 6.8p Cpar = 0
L166 331 332 290n
R166 332 333 0.17
C168 333 0 6.8p Cpar = 0
L167 333 334 290n
R167 334 335 0.17
C169 335 0 6.8p Cpar = 0
L168 335 336 290n
R168 336 337 0.17
C170 337 0 6.8p Cpar = 0
L169 337 338 290n
R169 338 339 0.17
C171 339 0 6.8p Cpar = 0
L170 339 340 290n
R170 340 341 0.17
C172 341 0 6.8p Cpar = 0
L171 341 342 290n
R171 342 343 0.17
C173 343 0 6.8p Cpar = 0
L172 343 344 290n
R172 344 345 0.17
C174 345 0 6.8p Cpar = 0
L173 345 346 290n
R173 346 347 0.17
C175 347 0 6.8p Cpar = 0
L174 347 348 290n
R174 348 349 0.17
C176 349 0 6.8p Cpar = 0
L175 349 350 290n
R175 350 351 0.17
C177 351 0 6.8p Cpar = 0
L176 351 352 290n
R176 352 353 0.17
C178 353 0 6.8p Cpar = 0
L177 353 354 290n
R177 354 355 0.17
C179 355 0 6.8p Cpar = 0
L178 355 356 290n
R178 356 357 0.17
C180 357 0 6.8p Cpar = 0
L179 357 358 290n
R179 358 359 0.17
C181 359 0 6.8p Cpar = 0
L180 359 360 290n
R180 360 361 0.17
C182 361 0 6.8p Cpar = 0
L181 361 362 290n
R181 362 363 0.17
C183 363 0 6.8p Cpar = 0
L182 363 364 290n
R182 364 365 0.17
C184 365 0 6.8p Cpar = 0
L183 365 366 290n
R183 366 367 0.17
C185 367 0 6.8p Cpar = 0
L184 367 368 290n
R184 368 369 0.17
C186 369 0 6.8p Cpar = 0
L185 369 370 290n
R185 370 371 0.17
C187 371 0 6.8p Cpar = 0
L186 371 372 290n
R186 372 373 0.17
C188 373 0 6.8p Cpar = 0
L187 373 374 290n
R187 374 375 0.17
C189 375 0 6.8p Cpar = 0
L188 375 376 290n
R188 376 377 0.17
C190 377 0 6.8p Cpar = 0
L189 377 378 290n
R189 378 379 0.17
C191 379 0 6.8p Cpar = 0
L190 379 380 290n
R190 380 381 0.17
C192 381 0 6.8p Cpar = 0
L191 381 382 290n
R191 382 383 0.17
C193 383 0 6.8p Cpar = 0
L192 383 384 290n
R192 384 385 0.17
C194 385 0 6.8p Cpar = 0
L193 385 386 290n
R193 386 387 0.17
C195 387 0 6.8p Cpar = 0
L194 387 388 290n
R194 388 389 0.17
C196 389 0 6.8p Cpar = 0
L195 389 390 290n
R195 390 391 0.17
C197 391 0 6.8p Cpar = 0
L196 391 392 290n
R196 392 393 0.17
C198 393 0 6.8p Cpar = 0
L197 393 394 290n
R197 394 395 0.17
C199 395 0 6.8p Cpar = 0
L198 395 396 290n
R198 396 397 0.17
C200 397 0 6.8p Cpar = 0
L199 397 398 290n
R199 398 399 0.17
C201 399 0 6.8p Cpar = 0
L200 399 400 290n
R200 400 401 0.17
C202 401 0 6.8p Cpar = 0
L201 401 402 290n
R201 402 403 0.17
C203 403 0 6.8p Cpar = 0
L202 403 404 290n
R202 404 405 0.17
C204 405 0 6.8p Cpar = 0
L203 405 406 290n
R203 406 407 0.17
C205 407 0 6.8p Cpar = 0
L204 407 408 290n
R204 408 409 0.17
C206 409 0 6.8p Cpar = 0
L205 409 410 290n
R205 410 411 0.17
C207 411 0 6.8p Cpar = 0
L206 411 412 290n
R206 412 413 0.17
C208 413 0 6.8p Cpar = 0
L207 413 414 290n
R207 414 415 0.17
C209 415 0 6.8p Cpar = 0
L208 415 416 290n
R208 416 417 0.17
C210 417 0 6.8p Cpar = 0
L209 417 418 290n
R209 418 419 0.17
C211 419 0 6.8p Cpar = 0
L210 419 420 290n
R210 420 421 0.17
C212 421 0 6.8p Cpar = 0
L211 421 422 290n
R211 422 423 0.17
C213 423 0 6.8p Cpar = 0
L212 423 424 290n
R212 424 425 0.17
C214 425 0 6.8p Cpar = 0
L213 425 426 290n
R213 426 427 0.17
C215 427 0 6.8p Cpar = 0
L214 427 428 290n
R214 428 429 0.17
C216 429 0 6.8p Cpar = 0
L215 429 430 290n
R215 430 431 0.17
C217 431 0 6.8p Cpar = 0
L216 431 432 290n
R216 432 433 0.17
C218 433 0 6.8p Cpar = 0
L217 433 434 290n
R217 434 435 0.17
C219 435 0 6.8p Cpar = 0
L218 435 436 290n
R218 436 437 0.17
C220 437 0 6.8p Cpar = 0
L219 437 438 290n
R219 438 439 0.17
C221 439 0 6.8p Cpar = 0
L220 439 440 290n
R220 440 441 0.17
C222 441 0 6.8p Cpar = 0
L221 441 442 290n
R221 442 443 0.17
C223 443 0 6.8p Cpar = 0
L222 443 444 290n
R222 444 445 0.17
C224 445 0 6.8p Cpar = 0
L223 445 446 290n
R223 446 447 0.17
C225 447 0 6.8p Cpar = 0
L224 447 448 290n
R224 448 449 0.17
C226 449 0 6.8p Cpar = 0
L225 449 450 290n
R225 450 451 0.17
C227 451 0 6.8p Cpar = 0
L226 451 452 290n
R226 452 453 0.17
C228 453 0 6.8p Cpar = 0
L227 453 454 290n
R227 454 455 0.17
C229 455 0 6.8p Cpar = 0
L228 455 456 290n
R228 456 457 0.17
C230 457 0 6.8p Cpar = 0
L229 457 458 290n
R229 458 459 0.17
C231 459 0 6.8p Cpar = 0
L230 459 460 290n
R230 460 461 0.17
C232 461 0 6.8p Cpar = 0
L231 461 462 290n
R231 462 463 0.17
C233 463 0 6.8p Cpar = 0
L232 463 464 290n
R232 464 465 0.17
C234 465 0 6.8p Cpar = 0
L233 465 466 290n
R233 466 467 0.17
C235 467 0 6.8p Cpar = 0
L234 467 468 290n
R234 468 469 0.17
C236 469 0 6.8p Cpar = 0
L235 469 470 290n
R235 470 471 0.17
C237 471 0 6.8p Cpar = 0
L236 471 472 290n
R236 472 473 0.17
C238 473 0 6.8p Cpar = 0
L237 473 474 290n
R237 474 475 0.17
C239 475 0 6.8p Cpar = 0
L238 475 476 290n
R238 476 477 0.17
C240 477 0 6.8p Cpar = 0
L239 477 478 290n
R239 478 479 0.17
C241 479 0 6.8p Cpar = 0
L240 479 480 290n
R240 480 481 0.17
C242 481 0 6.8p Cpar = 0
L241 481 482 290n
R241 482 483 0.17
C243 483 0 6.8p Cpar = 0
L242 483 484 290n
R242 484 485 0.17
C244 485 0 6.8p Cpar = 0
L243 485 486 290n
R243 486 487 0.17
C245 487 0 6.8p Cpar = 0
L244 487 488 290n
R244 488 489 0.17
C246 489 0 6.8p Cpar = 0
L245 489 490 290n
R245 490 491 0.17
C247 491 0 6.8p Cpar = 0
L246 491 492 290n
R246 492 493 0.17
C248 493 0 6.8p Cpar = 0
L247 493 494 290n
R247 494 495 0.17
C249 495 0 6.8p Cpar = 0
L248 495 496 290n
R248 496 497 0.17
C250 497 0 6.8p Cpar = 0
L249 497 498 290n
R249 498 499 0.17
C251 499 0 6.8p Cpar = 0
L250 499 500 290n
R250 500 501 0.17
C252 501 0 6.8p Cpar = 0
L251 501 502 290n
R251 502 503 0.17
C253 503 0 6.8p Cpar = 0
L252 503 504 290n
R252 504 505 0.17
C254 505 0 6.8p Cpar = 0
L253 505 506 290n
R253 506 507 0.17
C255 507 0 6.8p Cpar = 0
L254 507 508 290n
R254 508 509 0.17
C256 509 0 6.8p Cpar = 0
L255 509 510 290n
R255 510 511 0.17
C257 511 0 6.8p Cpar = 0
L256 511 512 290n
R256 512 513 0.17
C258 513 0 6.8p Cpar = 0
L257 513 514 290n
R257 514 515 0.17
C259 515 0 6.8p Cpar = 0
L258 515 516 290n
R258 516 517 0.17
C260 517 0 6.8p Cpar = 0
L259 517 518 290n
R259 518 519 0.17
C261 519 0 6.8p Cpar = 0
L260 519 520 290n
R260 520 521 0.17
C262 521 0 6.8p Cpar = 0
L261 521 522 290n
R261 522 523 0.17
C263 523 0 6.8p Cpar = 0
L262 523 524 290n
R262 524 525 0.17
C264 525 0 6.8p Cpar = 0
L263 525 526 290n
R263 526 527 0.17
C265 527 0 6.8p Cpar = 0
L264 527 528 290n
R264 528 529 0.17
C266 529 0 6.8p Cpar = 0
L265 529 530 290n
R265 530 531 0.17
C267 531 0 6.8p Cpar = 0
L266 531 532 290n
R266 532 533 0.17
C268 533 0 6.8p Cpar = 0
L267 533 534 290n
R267 534 535 0.17
C269 535 0 6.8p Cpar = 0
L268 535 536 290n
R268 536 537 0.17
C270 537 0 6.8p Cpar = 0
L269 537 538 290n
R269 538 539 0.17
C271 539 0 6.8p Cpar = 0
L270 539 540 290n
R270 540 541 0.17
C272 541 0 6.8p Cpar = 0
L271 541 542 290n
R271 542 543 0.17
C273 543 0 6.8p Cpar = 0
L272 543 544 290n
R272 544 545 0.17
C274 545 0 6.8p Cpar = 0
L273 545 546 290n
R273 546 547 0.17
C275 547 0 6.8p Cpar = 0
L274 547 548 290n
R274 548 549 0.17
C276 549 0 6.8p Cpar = 0
L275 549 550 290n
R275 550 551 0.17
C277 551 0 6.8p Cpar = 0
L276 551 552 290n
R276 552 553 0.17
C278 553 0 6.8p Cpar = 0
L277 553 554 290n
R277 554 555 0.17
C279 555 0 6.8p Cpar = 0
L278 555 556 290n
R278 556 557 0.17
C280 557 0 6.8p Cpar = 0
L279 557 558 290n
R279 558 559 0.17
C281 559 0 6.8p Cpar = 0
L280 559 560 290n
R280 560 561 0.17
C282 561 0 6.8p Cpar = 0
L281 561 562 290n
R281 562 563 0.17
C283 563 0 6.8p Cpar = 0
L282 563 564 290n
R282 564 565 0.17
C284 565 0 6.8p Cpar = 0
L283 565 566 290n
R283 566 567 0.17
C285 567 0 6.8p Cpar = 0
L284 567 568 290n
R284 568 569 0.17
C286 569 0 6.8p Cpar = 0
L285 569 570 290n
R285 570 571 0.17
C287 571 0 6.8p Cpar = 0
L286 571 572 290n
R286 572 573 0.17
C288 573 0 6.8p Cpar = 0
L287 573 574 290n
R287 574 575 0.17
C289 575 0 6.8p Cpar = 0
L288 575 576 290n
R288 576 577 0.17
C290 577 0 6.8p Cpar = 0
L289 577 578 290n
R289 578 579 0.17
C291 579 0 6.8p Cpar = 0
L290 579 580 290n
R290 580 581 0.17
C292 581 0 6.8p Cpar = 0
L291 581 582 290n
R291 582 583 0.17
C293 583 0 6.8p Cpar = 0
L292 583 584 290n
R292 584 585 0.17
C294 585 0 6.8p Cpar = 0
L293 585 586 290n
R293 586 587 0.17
C295 587 0 6.8p Cpar = 0
L294 587 588 290n
R294 588 589 0.17
C296 589 0 6.8p Cpar = 0
L295 589 590 290n
R295 590 591 0.17
C297 591 0 6.8p Cpar = 0
L296 591 592 290n
R296 592 593 0.17
C298 593 0 6.8p Cpar = 0
L297 593 594 290n
R297 594 595 0.17
C299 595 0 6.8p Cpar = 0
L298 595 596 290n
R298 596 597 0.17
C300 597 0 6.8p Cpar = 0
L299 597 598 290n
R299 598 599 0.17
C301 599 0 6.8p Cpar = 0
L300 599 600 290n
R300 600 601 0.17
C302 601 0 6.8p Cpar = 0
L301 601 602 290n
R301 602 603 0.17
C303 603 0 6.8p Cpar = 0
L302 603 604 290n
R302 604 605 0.17
C304 605 0 6.8p Cpar = 0
L303 605 606 290n
R303 606 607 0.17
C305 607 0 6.8p Cpar = 0
L304 607 608 290n
R304 608 609 0.17
C306 609 0 6.8p Cpar = 0
L305 609 610 290n
R305 610 611 0.17
C307 611 0 6.8p Cpar = 0
L306 611 612 290n
R306 612 613 0.17
C308 613 0 6.8p Cpar = 0
L307 613 614 290n
R307 614 615 0.17
C309 615 0 6.8p Cpar = 0
L308 615 616 290n
R308 616 617 0.17
C310 617 0 6.8p Cpar = 0
L309 617 618 290n
R309 618 619 0.17
C311 619 0 6.8p Cpar = 0
L310 619 620 290n
R310 620 621 0.17
C312 621 0 6.8p Cpar = 0
L311 621 622 290n
R311 622 623 0.17
C313 623 0 6.8p Cpar = 0
L312 623 624 290n
R312 624 625 0.17
C314 625 0 6.8p Cpar = 0
L313 625 626 290n
R313 626 627 0.17
C315 627 0 6.8p Cpar = 0
L314 627 628 290n
R314 628 629 0.17
C316 629 0 6.8p Cpar = 0
L315 629 630 290n
R315 630 631 0.17
C317 631 0 6.8p Cpar = 0
L316 631 632 290n
R316 632 633 0.17
C318 633 0 6.8p Cpar = 0
L317 633 634 290n
R317 634 635 0.17
C319 635 0 6.8p Cpar = 0
L318 635 636 290n
R318 636 637 0.17
C320 637 0 6.8p Cpar = 0
L319 637 638 290n
R319 638 639 0.17
C321 639 0 6.8p Cpar = 0
L320 639 640 290n
R320 640 641 0.17
C322 641 0 6.8p Cpar = 0
L321 641 642 290n
R321 642 643 0.17
C323 643 0 6.8p Cpar = 0
L322 643 644 290n
R322 644 645 0.17
C324 645 0 6.8p Cpar = 0
L323 645 646 290n
R323 646 647 0.17
C325 647 0 6.8p Cpar = 0
L324 647 648 290n
R324 648 649 0.17
C326 649 0 6.8p Cpar = 0
L325 649 650 290n
R325 650 651 0.17
C327 651 0 6.8p Cpar = 0
L326 651 652 290n
R326 652 653 0.17
C328 653 0 6.8p Cpar = 0
L327 653 654 290n
R327 654 655 0.17
C329 655 0 6.8p Cpar = 0
L328 655 656 290n
R328 656 657 0.17
C330 657 0 6.8p Cpar = 0
L329 657 658 290n
R329 658 659 0.17
C331 659 0 6.8p Cpar = 0
L330 659 660 290n
R330 660 661 0.17
C332 661 0 6.8p Cpar = 0
L331 661 662 290n
R331 662 663 0.17
C333 663 0 6.8p Cpar = 0
L332 663 664 290n
R332 664 665 0.17
C334 665 0 6.8p Cpar = 0
L333 665 666 290n
R333 666 667 0.17
C335 667 0 6.8p Cpar = 0
L334 667 668 290n
R334 668 669 0.17
C336 669 0 6.8p Cpar = 0
L335 669 670 290n
R335 670 671 0.17
C337 671 0 6.8p Cpar = 0
L336 671 672 290n
R336 672 673 0.17
C338 673 0 6.8p Cpar = 0
L337 673 674 290n
R337 674 675 0.17
C339 675 0 6.8p Cpar = 0
L338 675 676 290n
R338 676 677 0.17
C340 677 0 6.8p Cpar = 0
L339 677 678 290n
R339 678 679 0.17
C341 679 0 6.8p Cpar = 0
L340 679 680 290n
R340 680 681 0.17
C342 681 0 6.8p Cpar = 0
L341 681 682 290n
R341 682 683 0.17
C343 683 0 6.8p Cpar = 0
L342 683 684 290n
R342 684 685 0.17
C344 685 0 6.8p Cpar = 0
L343 685 686 290n
R343 686 687 0.17
C345 687 0 6.8p Cpar = 0
L344 687 688 290n
R344 688 689 0.17
C346 689 0 6.8p Cpar = 0
L345 689 690 290n
R345 690 691 0.17
C347 691 0 6.8p Cpar = 0
L346 691 692 290n
R346 692 693 0.17
C348 693 0 6.8p Cpar = 0
L347 693 694 290n
R347 694 695 0.17
C349 695 0 6.8p Cpar = 0
L348 695 696 290n
R348 696 697 0.17
C350 697 0 6.8p Cpar = 0
L349 697 698 290n
R349 698 699 0.17
C351 699 0 6.8p Cpar = 0
L350 699 700 290n
R350 700 701 0.17
C352 701 0 6.8p Cpar = 0
L351 701 702 290n
R351 702 703 0.17
C353 703 0 6.8p Cpar = 0
L352 703 704 290n
R352 704 705 0.17
C354 705 0 6.8p Cpar = 0
L353 705 706 290n
R353 706 707 0.17
C355 707 0 6.8p Cpar = 0
L354 707 708 290n
R354 708 709 0.17
C356 709 0 6.8p Cpar = 0
L355 709 710 290n
R355 710 711 0.17
C357 711 0 6.8p Cpar = 0
L356 711 712 290n
R356 712 713 0.17
C358 713 0 6.8p Cpar = 0
L357 713 714 290n
R357 714 715 0.17
C359 715 0 6.8p Cpar = 0
L358 715 716 290n
R358 716 717 0.17
C360 717 0 6.8p Cpar = 0
L359 717 718 290n
R359 718 719 0.17
C361 719 0 6.8p Cpar = 0
L360 719 720 290n
R360 720 721 0.17
C362 721 0 6.8p Cpar = 0
L361 721 722 290n
R361 722 723 0.17
C363 723 0 6.8p Cpar = 0
L362 723 724 290n
R362 724 725 0.17
C364 725 0 6.8p Cpar = 0
L363 725 726 290n
R363 726 727 0.17
C365 727 0 6.8p Cpar = 0
L364 727 728 290n
R364 728 729 0.17
C366 729 0 6.8p Cpar = 0
L365 729 730 290n
R365 730 731 0.17
C367 731 0 6.8p Cpar = 0
L366 731 732 290n
R366 732 733 0.17
C368 733 0 6.8p Cpar = 0
L367 733 734 290n
R367 734 735 0.17
C369 735 0 6.8p Cpar = 0
L368 735 736 290n
R368 736 737 0.17
C370 737 0 6.8p Cpar = 0
L369 737 738 290n
R369 738 739 0.17
C371 739 0 6.8p Cpar = 0
L370 739 740 290n
R370 740 741 0.17
C372 741 0 6.8p Cpar = 0
L371 741 742 290n
R371 742 743 0.17
C373 743 0 6.8p Cpar = 0
L372 743 744 290n
R372 744 745 0.17
C374 745 0 6.8p Cpar = 0
L373 745 746 290n
R373 746 747 0.17
C375 747 0 6.8p Cpar = 0
L374 747 748 290n
R374 748 749 0.17
C376 749 0 6.8p Cpar = 0
L375 749 750 290n
R375 750 751 0.17
C377 751 0 6.8p Cpar = 0
L376 751 752 290n
R376 752 753 0.17
C378 753 0 6.8p Cpar = 0
L377 753 754 290n
R377 754 755 0.17
C379 755 0 6.8p Cpar = 0
L378 755 756 290n
R378 756 757 0.17
C380 757 0 6.8p Cpar = 0
L379 757 758 290n
R379 758 759 0.17
C381 759 0 6.8p Cpar = 0
L380 759 760 290n
R380 760 761 0.17
C382 761 0 6.8p Cpar = 0
L381 761 762 290n
R381 762 763 0.17
C383 763 0 6.8p Cpar = 0
L382 763 764 290n
R382 764 765 0.17
C384 765 0 6.8p Cpar = 0
L383 765 766 290n
R383 766 767 0.17
C385 767 0 6.8p Cpar = 0
L384 767 768 290n
R384 768 769 0.17
C386 769 0 6.8p Cpar = 0
L385 769 770 290n
R385 770 771 0.17
C387 771 0 6.8p Cpar = 0
L386 771 772 290n
R386 772 773 0.17
C388 773 0 6.8p Cpar = 0
L387 773 774 290n
R387 774 775 0.17
C389 775 0 6.8p Cpar = 0
L388 775 776 290n
R388 776 777 0.17
C390 777 0 6.8p Cpar = 0
L389 777 778 290n
R389 778 779 0.17
C391 779 0 6.8p Cpar = 0
L390 779 780 290n
R390 780 781 0.17
C392 781 0 6.8p Cpar = 0
L391 781 782 290n
R391 782 783 0.17
C393 783 0 6.8p Cpar = 0
L392 783 784 290n
R392 784 785 0.17
C394 785 0 6.8p Cpar = 0
L393 785 786 290n
R393 786 787 0.17
C395 787 0 6.8p Cpar = 0
L394 787 788 290n
R394 788 789 0.17
C396 789 0 6.8p Cpar = 0
L395 789 790 290n
R395 790 791 0.17
C397 791 0 6.8p Cpar = 0
L396 791 792 290n
R396 792 793 0.17
C398 793 0 6.8p Cpar = 0
L397 793 794 290n
R397 794 795 0.17
C399 795 0 6.8p Cpar = 0
L398 795 796 290n
R398 796 797 0.17
C400 797 0 6.8p Cpar = 0
L399 797 798 290n
R399 798 799 0.17
C401 799 0 6.8p Cpar = 0
L400 799 800 290n
R400 800 801 0.17
C402 801 0 6.8p Cpar = 0
L401 801 802 290n
R401 802 803 0.17
C403 803 0 6.8p Cpar = 0
L402 803 804 290n
R402 804 805 0.17
C404 805 0 6.8p Cpar = 0
L403 805 806 290n
R403 806 807 0.17
C405 807 0 6.8p Cpar = 0
L404 807 808 290n
R404 808 809 0.17
C406 809 0 6.8p Cpar = 0
L405 809 810 290n
R405 810 811 0.17
C407 811 0 6.8p Cpar = 0
L406 811 812 290n
R406 812 813 0.17
C408 813 0 6.8p Cpar = 0
L407 813 814 290n
R407 814 815 0.17
C409 815 0 6.8p Cpar = 0
L408 815 816 290n
R408 816 817 0.17
C410 817 0 6.8p Cpar = 0
L409 817 818 290n
R409 818 819 0.17
C411 819 0 6.8p Cpar = 0
L410 819 820 290n
R410 820 821 0.17
C412 821 0 6.8p Cpar = 0
L411 821 822 290n
R411 822 823 0.17
C413 823 0 6.8p Cpar = 0
L412 823 824 290n
R412 824 825 0.17
C414 825 0 6.8p Cpar = 0
L413 825 826 290n
R413 826 827 0.17
C415 827 0 6.8p Cpar = 0
L414 827 828 290n
R414 828 829 0.17
C416 829 0 6.8p Cpar = 0
L415 829 830 290n
R415 830 831 0.17
C417 831 0 6.8p Cpar = 0
L416 831 832 290n
R416 832 833 0.17
C418 833 0 6.8p Cpar = 0
L417 833 834 290n
R417 834 835 0.17
C419 835 0 6.8p Cpar = 0
L418 835 836 290n
R418 836 837 0.17
C420 837 0 6.8p Cpar = 0
L419 837 838 290n
R419 838 839 0.17
C421 839 0 6.8p Cpar = 0
L420 839 840 290n
R420 840 841 0.17
C422 841 0 6.8p Cpar = 0
L421 841 842 290n
R421 842 843 0.17
C423 843 0 6.8p Cpar = 0
L422 843 844 290n
R422 844 845 0.17
C424 845 0 6.8p Cpar = 0
L423 845 846 290n
R423 846 847 0.17
C425 847 0 6.8p Cpar = 0
L424 847 848 290n
R424 848 849 0.17
C426 849 0 6.8p Cpar = 0
L425 849 850 290n
R425 850 851 0.17
C427 851 0 6.8p Cpar = 0
L426 851 852 290n
R426 852 853 0.17
C428 853 0 6.8p Cpar = 0
L427 853 854 290n
R427 854 855 0.17
C429 855 0 6.8p Cpar = 0
L428 855 856 290n
R428 856 857 0.17
C430 857 0 6.8p Cpar = 0
L429 857 858 290n
R429 858 859 0.17
C431 859 0 6.8p Cpar = 0
L430 859 860 290n
R430 860 861 0.17
C432 861 0 6.8p Cpar = 0
L431 861 862 290n
R431 862 863 0.17
C433 863 0 6.8p Cpar = 0
L432 863 864 290n
R432 864 865 0.17
C434 865 0 6.8p Cpar = 0
L433 865 866 290n
R433 866 867 0.17
C435 867 0 6.8p Cpar = 0
L434 867 868 290n
R434 868 869 0.17
C436 869 0 6.8p Cpar = 0
L435 869 870 290n
R435 870 871 0.17
C437 871 0 6.8p Cpar = 0
L436 871 872 290n
R436 872 873 0.17
C438 873 0 6.8p Cpar = 0
L437 873 874 290n
R437 874 875 0.17
C439 875 0 6.8p Cpar = 0
L438 875 876 290n
R438 876 877 0.17
C440 877 0 6.8p Cpar = 0
L439 877 878 290n
R439 878 879 0.17
C441 879 0 6.8p Cpar = 0
L440 879 880 290n
R440 880 881 0.17
C442 881 0 6.8p Cpar = 0
L441 881 882 290n
R441 882 883 0.17
C443 883 0 6.8p Cpar = 0
L442 883 884 290n
R442 884 885 0.17
C444 885 0 6.8p Cpar = 0
L443 885 886 290n
R443 886 887 0.17
C445 887 0 6.8p Cpar = 0
L444 887 888 290n
R444 888 889 0.17
C446 889 0 6.8p Cpar = 0
L445 889 890 290n
R445 890 891 0.17
C447 891 0 6.8p Cpar = 0
L446 891 892 290n
R446 892 893 0.17
C448 893 0 6.8p Cpar = 0
L447 893 894 290n
R447 894 895 0.17
C449 895 0 6.8p Cpar = 0
L448 895 896 290n
R448 896 897 0.17
C450 897 0 6.8p Cpar = 0
L449 897 898 290n
R449 898 899 0.17
C451 899 0 6.8p Cpar = 0
L450 899 900 290n
R450 900 901 0.17
C452 901 0 6.8p Cpar = 0
L451 901 902 290n
R451 902 903 0.17
C453 903 0 6.8p Cpar = 0
L452 903 904 290n
R452 904 905 0.17
C454 905 0 6.8p Cpar = 0
L453 905 906 290n
R453 906 907 0.17
C455 907 0 6.8p Cpar = 0
L454 907 908 290n
R454 908 909 0.17
C456 909 0 6.8p Cpar = 0
L455 909 910 290n
R455 910 911 0.17
C457 911 0 6.8p Cpar = 0
L456 911 912 290n
R456 912 913 0.17
C458 913 0 6.8p Cpar = 0
L457 913 914 290n
R457 914 915 0.17
C459 915 0 6.8p Cpar = 0
L458 915 916 290n
R458 916 917 0.17
C460 917 0 6.8p Cpar = 0
L459 917 918 290n
R459 918 919 0.17
C461 919 0 6.8p Cpar = 0
L460 919 920 290n
R460 920 921 0.17
C462 921 0 6.8p Cpar = 0
L461 921 922 290n
R461 922 923 0.17
C463 923 0 6.8p Cpar = 0
L462 923 924 290n
R462 924 925 0.17
C464 925 0 6.8p Cpar = 0
L463 925 926 290n
R463 926 927 0.17
C465 927 0 6.8p Cpar = 0
L464 927 928 290n
R464 928 929 0.17
C466 929 0 6.8p Cpar = 0
L465 929 930 290n
R465 930 931 0.17
C467 931 0 6.8p Cpar = 0
L466 931 932 290n
R466 932 933 0.17
C468 933 0 6.8p Cpar = 0
L467 933 934 290n
R467 934 935 0.17
C469 935 0 6.8p Cpar = 0
L468 935 936 290n
R468 936 937 0.17
C470 937 0 6.8p Cpar = 0
L469 937 938 290n
R469 938 939 0.17
C471 939 0 6.8p Cpar = 0
L470 939 940 290n
R470 940 941 0.17
C472 941 0 6.8p Cpar = 0
L471 941 942 290n
R471 942 943 0.17
C473 943 0 6.8p Cpar = 0
L472 943 944 290n
R472 944 945 0.17
C474 945 0 6.8p Cpar = 0
L473 945 946 290n
R473 946 947 0.17
C475 947 0 6.8p Cpar = 0
L474 947 948 290n
R474 948 949 0.17
C476 949 0 6.8p Cpar = 0
L475 949 950 290n
R475 950 951 0.17
C477 951 0 6.8p Cpar = 0
L476 951 952 290n
R476 952 953 0.17
C478 953 0 6.8p Cpar = 0
L477 953 954 290n
R477 954 955 0.17
C479 955 0 6.8p Cpar = 0
L478 955 956 290n
R478 956 957 0.17
C480 957 0 6.8p Cpar = 0
L479 957 958 290n
R479 958 959 0.17
C481 959 0 6.8p Cpar = 0
L480 959 960 290n
R480 960 961 0.17
C482 961 0 6.8p Cpar = 0
L481 961 962 290n
R481 962 963 0.17
C483 963 0 6.8p Cpar = 0
L482 963 964 290n
R482 964 965 0.17
C484 965 0 6.8p Cpar = 0
L483 965 966 290n
R483 966 967 0.17
C485 967 0 6.8p Cpar = 0
L484 967 968 290n
R484 968 969 0.17
C486 969 0 6.8p Cpar = 0
L485 969 970 290n
R485 970 971 0.17
C487 971 0 6.8p Cpar = 0
L486 971 972 290n
R486 972 973 0.17
C488 973 0 6.8p Cpar = 0
L487 973 974 290n
R487 974 975 0.17
C489 975 0 6.8p Cpar = 0
L488 975 976 290n
R488 976 977 0.17
C490 977 0 6.8p Cpar = 0
L489 977 978 290n
R489 978 979 0.17
C491 979 0 6.8p Cpar = 0
L490 979 980 290n
R490 980 981 0.17
C492 981 0 6.8p Cpar = 0
L491 981 982 290n
R491 982 983 0.17
C493 983 0 6.8p Cpar = 0
L492 983 984 290n
R492 984 985 0.17
C494 985 0 6.8p Cpar = 0
L493 985 986 290n
R493 986 987 0.17
C495 987 0 6.8p Cpar = 0
L494 987 988 290n
R494 988 989 0.17
C496 989 0 6.8p Cpar = 0
L495 989 990 290n
R495 990 991 0.17
C497 991 0 6.8p Cpar = 0
L496 991 992 290n
R496 992 993 0.17
C498 993 0 6.8p Cpar = 0
L497 993 994 290n
R497 994 995 0.17
C499 995 0 6.8p Cpar = 0
L498 995 996 290n
R498 996 997 0.17
C500 997 0 6.8p Cpar = 0
L499 997 998 290n
R499 998 999 0.17
C501 999 0 6.8p Cpar = 0
L500 999 1000 290n
R500 1000 1001 0.17
C502 1001 0 6.8p Cpar = 0
L501 1001 1002 290n
R501 1002 1003 0.17
C503 1003 0 6.8p Cpar = 0
L502 1003 1004 290n
R502 1004 1005 0.17
C504 1005 0 6.8p Cpar = 0
L503 1005 1006 290n
R503 1006 1007 0.17
C505 1007 0 6.8p Cpar = 0
L504 1007 1008 290n
R504 1008 1009 0.17
C506 1009 0 6.8p Cpar = 0
L505 1009 1010 290n
R505 1010 1011 0.17
C507 1011 0 6.8p Cpar = 0
L506 1011 1012 290n
R506 1012 1013 0.17
C508 1013 0 6.8p Cpar = 0
L507 1013 1014 290n
R507 1014 1015 0.17
C509 1015 0 6.8p Cpar = 0
L508 1015 1016 290n
R508 1016 1017 0.17
C510 1017 0 6.8p Cpar = 0
L509 1017 1018 290n
R509 1018 1019 0.17
C511 1019 0 6.8p Cpar = 0
L510 1019 1020 290n
R510 1020 1021 0.17
C512 1021 0 6.8p Cpar = 0
L511 1021 1022 290n
R511 1022 1023 0.17
C513 1023 0 6.8p Cpar = 0
L512 1023 1024 290n
R512 1024 1025 0.17
C514 1025 0 6.8p Cpar = 0
L513 1025 1026 290n
R513 1026 1027 0.17
C515 1027 0 6.8p Cpar = 0
L514 1027 1028 290n
R514 1028 1029 0.17
C516 1029 0 6.8p Cpar = 0
L515 1029 1030 290n
R515 1030 1031 0.17
C517 1031 0 6.8p Cpar = 0
L516 1031 1032 290n
R516 1032 1033 0.17
C518 1033 0 6.8p Cpar = 0
L517 1033 1034 290n
R517 1034 1035 0.17
C519 1035 0 6.8p Cpar = 0
L518 1035 1036 290n
R518 1036 1037 0.17
C520 1037 0 6.8p Cpar = 0
L519 1037 1038 290n
R519 1038 1039 0.17
C521 1039 0 6.8p Cpar = 0
L520 1039 1040 290n
R520 1040 1041 0.17
C522 1041 0 6.8p Cpar = 0
L521 1041 1042 290n
R521 1042 1043 0.17
C523 1043 0 6.8p Cpar = 0
L522 1043 1044 290n
R522 1044 1045 0.17
C524 1045 0 6.8p Cpar = 0
L523 1045 1046 290n
R523 1046 1047 0.17
C525 1047 0 6.8p Cpar = 0
L524 1047 1048 290n
R524 1048 1049 0.17
C526 1049 0 6.8p Cpar = 0
L525 1049 1050 290n
R525 1050 1051 0.17
C527 1051 0 6.8p Cpar = 0
L526 1051 1052 290n
R526 1052 1053 0.17
C528 1053 0 6.8p Cpar = 0
L527 1053 1054 290n
R527 1054 1055 0.17
C529 1055 0 6.8p Cpar = 0
L528 1055 1056 290n
R528 1056 1057 0.17
C530 1057 0 6.8p Cpar = 0
L529 1057 1058 290n
R529 1058 1059 0.17
C531 1059 0 6.8p Cpar = 0
L530 1059 1060 290n
R530 1060 1061 0.17
C532 1061 0 6.8p Cpar = 0
L531 1061 1062 290n
R531 1062 1063 0.17
C533 1063 0 6.8p Cpar = 0
L532 1063 1064 290n
R532 1064 1065 0.17
C534 1065 0 6.8p Cpar = 0
L533 1065 1066 290n
R533 1066 1067 0.17
C535 1067 0 6.8p Cpar = 0
L534 1067 1068 290n
R534 1068 1069 0.17
C536 1069 0 6.8p Cpar = 0
L535 1069 1070 290n
R535 1070 1071 0.17
C537 1071 0 6.8p Cpar = 0
L536 1071 1072 290n
R536 1072 1073 0.17
C538 1073 0 6.8p Cpar = 0
L537 1073 1074 290n
R537 1074 1075 0.17
C539 1075 0 6.8p Cpar = 0
L538 1075 1076 290n
R538 1076 1077 0.17
C540 1077 0 6.8p Cpar = 0
L539 1077 1078 290n
R539 1078 1079 0.17
C541 1079 0 6.8p Cpar = 0
L540 1079 1080 290n
R540 1080 1081 0.17
C542 1081 0 6.8p Cpar = 0
L541 1081 1082 290n
R541 1082 1083 0.17
C543 1083 0 6.8p Cpar = 0
L542 1083 1084 290n
R542 1084 1085 0.17
C544 1085 0 6.8p Cpar = 0
L543 1085 1086 290n
R543 1086 1087 0.17
C545 1087 0 6.8p Cpar = 0
L544 1087 1088 290n
R544 1088 1089 0.17
C546 1089 0 6.8p Cpar = 0
L545 1089 1090 290n
R545 1090 1091 0.17
C547 1091 0 6.8p Cpar = 0
L546 1091 1092 290n
R546 1092 1093 0.17
C548 1093 0 6.8p Cpar = 0
L547 1093 1094 290n
R547 1094 1095 0.17
C549 1095 0 6.8p Cpar = 0
L548 1095 1096 290n
R548 1096 1097 0.17
C550 1097 0 6.8p Cpar = 0
L549 1097 1098 290n
R549 1098 1099 0.17
C551 1099 0 6.8p Cpar = 0
L550 1099 1100 290n
R550 1100 1101 0.17
C552 1101 0 6.8p Cpar = 0
L551 1101 1102 290n
R551 1102 1103 0.17
C553 1103 0 6.8p Cpar = 0
L552 1103 1104 290n
R552 1104 1105 0.17
C554 1105 0 6.8p Cpar = 0
L553 1105 1106 290n
R553 1106 1107 0.17
C555 1107 0 6.8p Cpar = 0
L554 1107 1108 290n
R554 1108 1109 0.17
C556 1109 0 6.8p Cpar = 0
L555 1109 1110 290n
R555 1110 1111 0.17
C557 1111 0 6.8p Cpar = 0
L556 1111 1112 290n
R556 1112 1113 0.17
C558 1113 0 6.8p Cpar = 0
L557 1113 1114 290n
R557 1114 1115 0.17
C559 1115 0 6.8p Cpar = 0
L558 1115 1116 290n
R558 1116 1117 0.17
C560 1117 0 6.8p Cpar = 0
L559 1117 1118 290n
R559 1118 1119 0.17
C561 1119 0 6.8p Cpar = 0
L560 1119 1120 290n
R560 1120 1121 0.17
C562 1121 0 6.8p Cpar = 0
L561 1121 1122 290n
R561 1122 1123 0.17
C563 1123 0 6.8p Cpar = 0
L562 1123 1124 290n
R562 1124 1125 0.17
C564 1125 0 6.8p Cpar = 0
L563 1125 1126 290n
R563 1126 1127 0.17
C565 1127 0 6.8p Cpar = 0
L564 1127 1128 290n
R564 1128 1129 0.17
C566 1129 0 6.8p Cpar = 0
L565 1129 1130 290n
R565 1130 1131 0.17
C567 1131 0 6.8p Cpar = 0
L566 1131 1132 290n
R566 1132 1133 0.17
C568 1133 0 6.8p Cpar = 0
L567 1133 1134 290n
R567 1134 1135 0.17
C569 1135 0 6.8p Cpar = 0
L568 1135 1136 290n
R568 1136 1137 0.17
C570 1137 0 6.8p Cpar = 0
L569 1137 1138 290n
R569 1138 1139 0.17
C571 1139 0 6.8p Cpar = 0
L570 1139 1140 290n
R570 1140 1141 0.17
C572 1141 0 6.8p Cpar = 0
L571 1141 1142 290n
R571 1142 1143 0.17
C573 1143 0 6.8p Cpar = 0
L572 1143 1144 290n
R572 1144 1145 0.17
C574 1145 0 6.8p Cpar = 0
L573 1145 1146 290n
R573 1146 1147 0.17
C575 1147 0 6.8p Cpar = 0
L574 1147 1148 290n
R574 1148 1149 0.17
C576 1149 0 6.8p Cpar = 0
L575 1149 1150 290n
R575 1150 1151 0.17
C577 1151 0 6.8p Cpar = 0
L576 1151 1152 290n
R576 1152 1153 0.17
C578 1153 0 6.8p Cpar = 0
L577 1153 1154 290n
R577 1154 1155 0.17
C579 1155 0 6.8p Cpar = 0
L578 1155 1156 290n
R578 1156 1157 0.17
C580 1157 0 6.8p Cpar = 0
L579 1157 1158 290n
R579 1158 1159 0.17
C581 1159 0 6.8p Cpar = 0
L580 1159 1160 290n
R580 1160 1161 0.17
C582 1161 0 6.8p Cpar = 0
L581 1161 1162 290n
R581 1162 1163 0.17
C583 1163 0 6.8p Cpar = 0
L582 1163 1164 290n
R582 1164 1165 0.17
C584 1165 0 6.8p Cpar = 0
L583 1165 1166 290n
R583 1166 1167 0.17
C585 1167 0 6.8p Cpar = 0
L584 1167 1168 290n
R584 1168 1169 0.17
C586 1169 0 6.8p Cpar = 0
L585 1169 1170 290n
R585 1170 1171 0.17
C587 1171 0 6.8p Cpar = 0
L586 1171 1172 290n
R586 1172 1173 0.17
C588 1173 0 6.8p Cpar = 0
L587 1173 1174 290n
R587 1174 1175 0.17
C589 1175 0 6.8p Cpar = 0
L588 1175 1176 290n
R588 1176 1177 0.17
C590 1177 0 6.8p Cpar = 0
L589 1177 1178 290n
R589 1178 1179 0.17
C591 1179 0 6.8p Cpar = 0
L590 1179 1180 290n
R590 1180 1181 0.17
C592 1181 0 6.8p Cpar = 0
L591 1181 1182 290n
R591 1182 1183 0.17
C593 1183 0 6.8p Cpar = 0
L592 1183 1184 290n
R592 1184 1185 0.17
C594 1185 0 6.8p Cpar = 0
L593 1185 1186 290n
R593 1186 1187 0.17
C595 1187 0 6.8p Cpar = 0
L594 1187 1188 290n
R594 1188 1189 0.17
C596 1189 0 6.8p Cpar = 0
L595 1189 1190 290n
R595 1190 1191 0.17
C597 1191 0 6.8p Cpar = 0
L596 1191 1192 290n
R596 1192 1193 0.17
C598 1193 0 6.8p Cpar = 0
L597 1193 1194 290n
R597 1194 1195 0.17
C599 1195 0 6.8p Cpar = 0
L598 1195 1196 290n
R598 1196 1197 0.17
C600 1197 0 6.8p Cpar = 0
L599 1197 1198 290n
R599 1198 1199 0.17
C601 1199 0 6.8p Cpar = 0
L600 1199 1200 290n
R600 1200 1201 0.17
C602 1201 0 6.8p Cpar = 0
L601 1201 1202 290n
R601 1202 1203 0.17
C603 1203 0 6.8p Cpar = 0
L602 1203 1204 290n
R602 1204 1205 0.17
C604 1205 0 6.8p Cpar = 0
L603 1205 1206 290n
R603 1206 1207 0.17
C605 1207 0 6.8p Cpar = 0
L604 1207 1208 290n
R604 1208 1209 0.17
C606 1209 0 6.8p Cpar = 0
L605 1209 1210 290n
R605 1210 1211 0.17
C607 1211 0 6.8p Cpar = 0
L606 1211 1212 290n
R606 1212 1213 0.17
C608 1213 0 6.8p Cpar = 0
L607 1213 1214 290n
R607 1214 1215 0.17
C609 1215 0 6.8p Cpar = 0
L608 1215 1216 290n
R608 1216 1217 0.17
C610 1217 0 6.8p Cpar = 0
L609 1217 1218 290n
R609 1218 1219 0.17
C611 1219 0 6.8p Cpar = 0
L610 1219 1220 290n
R610 1220 1221 0.17
C612 1221 0 6.8p Cpar = 0
L611 1221 1222 290n
R611 1222 1223 0.17
C613 1223 0 6.8p Cpar = 0
L612 1223 1224 290n
R612 1224 1225 0.17
C614 1225 0 6.8p Cpar = 0
L613 1225 1226 290n
R613 1226 1227 0.17
C615 1227 0 6.8p Cpar = 0
L614 1227 1228 290n
R614 1228 1229 0.17
C616 1229 0 6.8p Cpar = 0
L615 1229 1230 290n
R615 1230 1231 0.17
C617 1231 0 6.8p Cpar = 0
L616 1231 1232 290n
R616 1232 1233 0.17
C618 1233 0 6.8p Cpar = 0
L617 1233 1234 290n
R617 1234 1235 0.17
C619 1235 0 6.8p Cpar = 0
L618 1235 1236 290n
R618 1236 1237 0.17
C620 1237 0 6.8p Cpar = 0
L619 1237 1238 290n
R619 1238 1239 0.17
C621 1239 0 6.8p Cpar = 0
L620 1239 1240 290n
R620 1240 1241 0.17
C622 1241 0 6.8p Cpar = 0
L621 1241 1242 290n
R621 1242 1243 0.17
C623 1243 0 6.8p Cpar = 0
L622 1243 1244 290n
R622 1244 1245 0.17
C624 1245 0 6.8p Cpar = 0
L623 1245 1246 290n
R623 1246 1247 0.17
C625 1247 0 6.8p Cpar = 0
L624 1247 1248 290n
R624 1248 1249 0.17
C626 1249 0 6.8p Cpar = 0
L625 1249 1250 290n
R625 1250 1251 0.17
C627 1251 0 6.8p Cpar = 0
L626 1251 1252 290n
R626 1252 1253 0.17
C628 1253 0 6.8p Cpar = 0
L627 1253 1254 290n
R627 1254 1255 0.17
C629 1255 0 6.8p Cpar = 0
L628 1255 1256 290n
R628 1256 1257 0.17
C630 1257 0 6.8p Cpar = 0
L629 1257 1258 290n
R629 1258 1259 0.17
C631 1259 0 6.8p Cpar = 0
L630 1259 1260 290n
R630 1260 1261 0.17
C632 1261 0 6.8p Cpar = 0
L631 1261 1262 290n
R631 1262 1263 0.17
C633 1263 0 6.8p Cpar = 0
L632 1263 1264 290n
R632 1264 1265 0.17
C634 1265 0 6.8p Cpar = 0
L633 1265 1266 290n
R633 1266 1267 0.17
C635 1267 0 6.8p Cpar = 0
L634 1267 1268 290n
R634 1268 1269 0.17
C636 1269 0 6.8p Cpar = 0
L635 1269 1270 290n
R635 1270 1271 0.17
C637 1271 0 6.8p Cpar = 0
L636 1271 1272 290n
R636 1272 1273 0.17
C638 1273 0 6.8p Cpar = 0
L637 1273 1274 290n
R637 1274 1275 0.17
C639 1275 0 6.8p Cpar = 0
L638 1275 1276 290n
R638 1276 1277 0.17
C640 1277 0 6.8p Cpar = 0
L639 1277 1278 290n
R639 1278 1279 0.17
C641 1279 0 6.8p Cpar = 0
L640 1279 1280 290n
R640 1280 1281 0.17
C642 1281 0 6.8p Cpar = 0
L641 1281 1282 290n
R641 1282 1283 0.17
C643 1283 0 6.8p Cpar = 0
L642 1283 1284 290n
R642 1284 1285 0.17
C644 1285 0 6.8p Cpar = 0
L643 1285 1286 290n
R643 1286 1287 0.17
C645 1287 0 6.8p Cpar = 0
L644 1287 1288 290n
R644 1288 1289 0.17
C646 1289 0 6.8p Cpar = 0
L645 1289 1290 290n
R645 1290 1291 0.17
C647 1291 0 6.8p Cpar = 0
L646 1291 1292 290n
R646 1292 1293 0.17
C648 1293 0 6.8p Cpar = 0
L647 1293 1294 290n
R647 1294 1295 0.17
C649 1295 0 6.8p Cpar = 0
L648 1295 1296 290n
R648 1296 1297 0.17
C650 1297 0 6.8p Cpar = 0
L649 1297 1298 290n
R649 1298 1299 0.17
C651 1299 0 6.8p Cpar = 0
L650 1299 1300 290n
R650 1300 1301 0.17
C652 1301 0 6.8p Cpar = 0
L651 1301 1302 290n
R651 1302 1303 0.17
C653 1303 0 6.8p Cpar = 0
L652 1303 1304 290n
R652 1304 1305 0.17
C654 1305 0 6.8p Cpar = 0
L653 1305 1306 290n
R653 1306 1307 0.17
C655 1307 0 6.8p Cpar = 0
L654 1307 1308 290n
R654 1308 1309 0.17
C656 1309 0 6.8p Cpar = 0
L655 1309 1310 290n
R655 1310 1311 0.17
C657 1311 0 6.8p Cpar = 0
L656 1311 1312 290n
R656 1312 1313 0.17
C658 1313 0 6.8p Cpar = 0
L657 1313 1314 290n
R657 1314 1315 0.17
C659 1315 0 6.8p Cpar = 0
L658 1315 1316 290n
R658 1316 1317 0.17
C660 1317 0 6.8p Cpar = 0
L659 1317 1318 290n
R659 1318 1319 0.17
C661 1319 0 6.8p Cpar = 0
L660 1319 1320 290n
R660 1320 1321 0.17
C662 1321 0 6.8p Cpar = 0
L661 1321 1322 290n
R661 1322 1323 0.17
C663 1323 0 6.8p Cpar = 0
L662 1323 1324 290n
R662 1324 1325 0.17
C664 1325 0 6.8p Cpar = 0
L663 1325 1326 290n
R663 1326 1327 0.17
C665 1327 0 6.8p Cpar = 0
L664 1327 1328 290n
R664 1328 1329 0.17
C666 1329 0 6.8p Cpar = 0
L665 1329 1330 290n
R665 1330 1331 0.17
C667 1331 0 6.8p Cpar = 0
L666 1331 1332 290n
R666 1332 1333 0.17
C668 1333 0 6.8p Cpar = 0
L667 1333 1334 290n
R667 1334 1335 0.17
C669 1335 0 6.8p Cpar = 0
L668 1335 1336 290n
R668 1336 1337 0.17
C670 1337 0 6.8p Cpar = 0
L669 1337 1338 290n
R669 1338 1339 0.17
C671 1339 0 6.8p Cpar = 0
L670 1339 1340 290n
R670 1340 1341 0.17
C672 1341 0 6.8p Cpar = 0
L671 1341 1342 290n
R671 1342 1343 0.17
C673 1343 0 6.8p Cpar = 0
L672 1343 1344 290n
R672 1344 1345 0.17
C674 1345 0 6.8p Cpar = 0
L673 1345 1346 290n
R673 1346 1347 0.17
C675 1347 0 6.8p Cpar = 0
L674 1347 1348 290n
R674 1348 1349 0.17
C676 1349 0 6.8p Cpar = 0
L675 1349 1350 290n
R675 1350 1351 0.17
C677 1351 0 6.8p Cpar = 0
L676 1351 1352 290n
R676 1352 1353 0.17
C678 1353 0 6.8p Cpar = 0
L677 1353 1354 290n
R677 1354 1355 0.17
C679 1355 0 6.8p Cpar = 0
L678 1355 1356 290n
R678 1356 1357 0.17
C680 1357 0 6.8p Cpar = 0
L679 1357 1358 290n
R679 1358 1359 0.17
C681 1359 0 6.8p Cpar = 0
L680 1359 1360 290n
R680 1360 1361 0.17
C682 1361 0 6.8p Cpar = 0
L681 1361 1362 290n
R681 1362 1363 0.17
C683 1363 0 6.8p Cpar = 0
L682 1363 1364 290n
R682 1364 1365 0.17
C684 1365 0 6.8p Cpar = 0
L683 1365 1366 290n
R683 1366 1367 0.17
C685 1367 0 6.8p Cpar = 0
L684 1367 1368 290n
R684 1368 1369 0.17
C686 1369 0 6.8p Cpar = 0
L685 1369 1370 290n
R685 1370 1371 0.17
C687 1371 0 6.8p Cpar = 0
L686 1371 1372 290n
R686 1372 1373 0.17
C688 1373 0 6.8p Cpar = 0
L687 1373 1374 290n
R687 1374 1375 0.17
C689 1375 0 6.8p Cpar = 0
L688 1375 1376 290n
R688 1376 1377 0.17
C690 1377 0 6.8p Cpar = 0
L689 1377 1378 290n
R689 1378 1379 0.17
C691 1379 0 6.8p Cpar = 0
L690 1379 1380 290n
R690 1380 1381 0.17
C692 1381 0 6.8p Cpar = 0
L691 1381 1382 290n
R691 1382 1383 0.17
C693 1383 0 6.8p Cpar = 0
L692 1383 1384 290n
R692 1384 1385 0.17
C694 1385 0 6.8p Cpar = 0
L693 1385 1386 290n
R693 1386 1387 0.17
C695 1387 0 6.8p Cpar = 0
L694 1387 1388 290n
R694 1388 1389 0.17
C696 1389 0 6.8p Cpar = 0
L695 1389 1390 290n
R695 1390 1391 0.17
C697 1391 0 6.8p Cpar = 0
L696 1391 1392 290n
R696 1392 1393 0.17
C698 1393 0 6.8p Cpar = 0
L697 1393 1394 290n
R697 1394 1395 0.17
C699 1395 0 6.8p Cpar = 0
L698 1395 1396 290n
R698 1396 1397 0.17
C700 1397 0 6.8p Cpar = 0
L699 1397 1398 290n
R699 1398 1399 0.17
C701 1399 0 6.8p Cpar = 0
L700 1399 1400 290n
R700 1400 1401 0.17
C702 1401 0 6.8p Cpar = 0
L701 1401 1402 290n
R701 1402 1403 0.17
C703 1403 0 6.8p Cpar = 0
L702 1403 1404 290n
R702 1404 1405 0.17
C704 1405 0 6.8p Cpar = 0
L703 1405 1406 290n
R703 1406 1407 0.17
C705 1407 0 6.8p Cpar = 0
L704 1407 1408 290n
R704 1408 1409 0.17
C706 1409 0 6.8p Cpar = 0
L705 1409 1410 290n
R705 1410 1411 0.17
C707 1411 0 6.8p Cpar = 0
L706 1411 1412 290n
R706 1412 1413 0.17
C708 1413 0 6.8p Cpar = 0
L707 1413 1414 290n
R707 1414 1415 0.17
C709 1415 0 6.8p Cpar = 0
L708 1415 1416 290n
R708 1416 1417 0.17
C710 1417 0 6.8p Cpar = 0
L709 1417 1418 290n
R709 1418 1419 0.17
C711 1419 0 6.8p Cpar = 0
L710 1419 1420 290n
R710 1420 1421 0.17
C712 1421 0 6.8p Cpar = 0
L711 1421 1422 290n
R711 1422 1423 0.17
C713 1423 0 6.8p Cpar = 0
L712 1423 1424 290n
R712 1424 1425 0.17
C714 1425 0 6.8p Cpar = 0
L713 1425 1426 290n
R713 1426 1427 0.17
C715 1427 0 6.8p Cpar = 0
L714 1427 1428 290n
R714 1428 1429 0.17
C716 1429 0 6.8p Cpar = 0
L715 1429 1430 290n
R715 1430 1431 0.17
C717 1431 0 6.8p Cpar = 0
L716 1431 1432 290n
R716 1432 1433 0.17
C718 1433 0 6.8p Cpar = 0
L717 1433 1434 290n
R717 1434 1435 0.17
C719 1435 0 6.8p Cpar = 0
L718 1435 1436 290n
R718 1436 1437 0.17
C720 1437 0 6.8p Cpar = 0
L719 1437 1438 290n
R719 1438 1439 0.17
C721 1439 0 6.8p Cpar = 0
L720 1439 1440 290n
R720 1440 1441 0.17
C722 1441 0 6.8p Cpar = 0
L721 1441 1442 290n
R721 1442 1443 0.17
C723 1443 0 6.8p Cpar = 0
L722 1443 1444 290n
R722 1444 1445 0.17
C724 1445 0 6.8p Cpar = 0
L723 1445 1446 290n
R723 1446 1447 0.17
C725 1447 0 6.8p Cpar = 0
L724 1447 1448 290n
R724 1448 1449 0.17
C726 1449 0 6.8p Cpar = 0
L725 1449 1450 290n
R725 1450 1451 0.17
C727 1451 0 6.8p Cpar = 0
L726 1451 1452 290n
R726 1452 1453 0.17
C728 1453 0 6.8p Cpar = 0
L727 1453 1454 290n
R727 1454 1455 0.17
C729 1455 0 6.8p Cpar = 0
L728 1455 1456 290n
R728 1456 1457 0.17
C730 1457 0 6.8p Cpar = 0
L729 1457 1458 290n
R729 1458 1459 0.17
C731 1459 0 6.8p Cpar = 0
L730 1459 1460 290n
R730 1460 1461 0.17
C732 1461 0 6.8p Cpar = 0
L731 1461 1462 290n
R731 1462 1463 0.17
C733 1463 0 6.8p Cpar = 0
L732 1463 1464 290n
R732 1464 1465 0.17
C734 1465 0 6.8p Cpar = 0
L733 1465 1466 290n
R733 1466 1467 0.17
C735 1467 0 6.8p Cpar = 0
L734 1467 1468 290n
R734 1468 1469 0.17
C736 1469 0 6.8p Cpar = 0
L735 1469 1470 290n
R735 1470 1471 0.17
C737 1471 0 6.8p Cpar = 0
L736 1471 1472 290n
R736 1472 1473 0.17
C738 1473 0 6.8p Cpar = 0
L737 1473 1474 290n
R737 1474 1475 0.17
C739 1475 0 6.8p Cpar = 0
L738 1475 1476 290n
R738 1476 1477 0.17
C740 1477 0 6.8p Cpar = 0
L739 1477 1478 290n
R739 1478 1479 0.17
C741 1479 0 6.8p Cpar = 0
L740 1479 1480 290n
R740 1480 1481 0.17
C742 1481 0 6.8p Cpar = 0
L741 1481 1482 290n
R741 1482 1483 0.17
C743 1483 0 6.8p Cpar = 0
L742 1483 1484 290n
R742 1484 1485 0.17
C744 1485 0 6.8p Cpar = 0
L743 1485 1486 290n
R743 1486 1487 0.17
C745 1487 0 6.8p Cpar = 0
L744 1487 1488 290n
R744 1488 1489 0.17
C746 1489 0 6.8p Cpar = 0
L745 1489 1490 290n
R745 1490 1491 0.17
C747 1491 0 6.8p Cpar = 0
L746 1491 1492 290n
R746 1492 1493 0.17
C748 1493 0 6.8p Cpar = 0
L747 1493 1494 290n
R747 1494 1495 0.17
C749 1495 0 6.8p Cpar = 0
L748 1495 1496 290n
R748 1496 1497 0.17
C750 1497 0 6.8p Cpar = 0
L749 1497 1498 290n
R749 1498 1499 0.17
C751 1499 0 6.8p Cpar = 0
L750 1499 1500 290n
R750 1500 1501 0.17
C752 1501 0 6.8p Cpar = 0
L751 1501 1502 290n
R751 1502 1503 0.17
C753 1503 0 6.8p Cpar = 0
L752 1503 1504 290n
R752 1504 1505 0.17
C754 1505 0 6.8p Cpar = 0
L753 1505 1506 290n
R753 1506 1507 0.17
C755 1507 0 6.8p Cpar = 0
L754 1507 1508 290n
R754 1508 1509 0.17
C756 1509 0 6.8p Cpar = 0
L755 1509 1510 290n
R755 1510 1511 0.17
C757 1511 0 6.8p Cpar = 0
L756 1511 1512 290n
R756 1512 1513 0.17
C758 1513 0 6.8p Cpar = 0
L757 1513 1514 290n
R757 1514 1515 0.17
C759 1515 0 6.8p Cpar = 0
L758 1515 1516 290n
R758 1516 1517 0.17
C760 1517 0 6.8p Cpar = 0
L759 1517 1518 290n
R759 1518 1519 0.17
C761 1519 0 6.8p Cpar = 0
L760 1519 1520 290n
R760 1520 1521 0.17
C762 1521 0 6.8p Cpar = 0
L761 1521 1522 290n
R761 1522 1523 0.17
C763 1523 0 6.8p Cpar = 0
L762 1523 1524 290n
R762 1524 1525 0.17
C764 1525 0 6.8p Cpar = 0
L763 1525 1526 290n
R763 1526 1527 0.17
C765 1527 0 6.8p Cpar = 0
L764 1527 1528 290n
R764 1528 1529 0.17
C766 1529 0 6.8p Cpar = 0
L765 1529 1530 290n
R765 1530 1531 0.17
C767 1531 0 6.8p Cpar = 0
L766 1531 1532 290n
R766 1532 1533 0.17
C768 1533 0 6.8p Cpar = 0
L767 1533 1534 290n
R767 1534 1535 0.17
C769 1535 0 6.8p Cpar = 0
L768 1535 1536 290n
R768 1536 1537 0.17
C770 1537 0 6.8p Cpar = 0
L769 1537 1538 290n
R769 1538 1539 0.17
C771 1539 0 6.8p Cpar = 0
L770 1539 1540 290n
R770 1540 1541 0.17
C772 1541 0 6.8p Cpar = 0
L771 1541 1542 290n
R771 1542 1543 0.17
C773 1543 0 6.8p Cpar = 0
L772 1543 1544 290n
R772 1544 1545 0.17
C774 1545 0 6.8p Cpar = 0
L773 1545 1546 290n
R773 1546 1547 0.17
C775 1547 0 6.8p Cpar = 0
L774 1547 1548 290n
R774 1548 1549 0.17
C776 1549 0 6.8p Cpar = 0
L775 1549 1550 290n
R775 1550 1551 0.17
C777 1551 0 6.8p Cpar = 0
L776 1551 1552 290n
R776 1552 1553 0.17
C778 1553 0 6.8p Cpar = 0
L777 1553 1554 290n
R777 1554 1555 0.17
C779 1555 0 6.8p Cpar = 0
L778 1555 1556 290n
R778 1556 1557 0.17
C780 1557 0 6.8p Cpar = 0
L779 1557 1558 290n
R779 1558 1559 0.17
C781 1559 0 6.8p Cpar = 0
L780 1559 1560 290n
R780 1560 -1 0.17
C782 -1 0 6.8p Cpar = 0
R781 -1 0 220

.tran 1450n
