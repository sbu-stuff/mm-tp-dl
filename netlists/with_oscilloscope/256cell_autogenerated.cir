*Auto-gererated 256-cell delay line circuit

V1 1 0 PULSE(0 1 0 7.5n 7.5n 100n 1 1)
R1 1 0 220
C2 1 0 6.8p
L2 1 2 290n
R3 2 3 0.17
C3 3 0 6.8p
L3 3 4 290n
R4 4 5 0.17
C4 5 0 6.8p
L4 5 6 290n
R5 6 7 0.17
C5 7 0 6.8p
L5 7 8 290n
R6 8 9 0.17
C6 9 0 6.8p
L6 9 10 290n
R7 10 11 0.17
C7 11 0 6.8p
L7 11 12 290n
R8 12 13 0.17
C8 13 0 6.8p
L8 13 14 290n
R9 14 15 0.17
C9 15 0 6.8p
L9 15 16 290n
R10 16 17 0.17
C10 17 0 6.8p
L10 17 18 290n
R11 18 19 0.17
C11 19 0 6.8p
L11 19 20 290n
R12 20 21 0.17
C12 21 0 6.8p
L12 21 22 290n
R13 22 23 0.17
C13 23 0 6.8p
L13 23 24 290n
R14 24 25 0.17
C14 25 0 6.8p
L14 25 26 290n
R15 26 27 0.17
C15 27 0 6.8p
L15 27 28 290n
R16 28 29 0.17
C16 29 0 6.8p
L16 29 30 290n
R17 30 31 0.17
C17 31 0 6.8p
L17 31 32 290n
R18 32 33 0.17
C18 33 0 6.8p
L18 33 34 290n
R19 34 35 0.17
C19 35 0 6.8p
L19 35 36 290n
R20 36 37 0.17
C20 37 0 6.8p
L20 37 38 290n
R21 38 39 0.17
C21 39 0 6.8p
L21 39 40 290n
R22 40 41 0.17
C22 41 0 6.8p
L22 41 42 290n
R23 42 43 0.17
C23 43 0 6.8p
L23 43 44 290n
R24 44 45 0.17
C24 45 0 6.8p
L24 45 46 290n
R25 46 47 0.17
C25 47 0 6.8p
L25 47 48 290n
R26 48 49 0.17
C26 49 0 6.8p
L26 49 50 290n
R27 50 51 0.17
C27 51 0 6.8p
L27 51 52 290n
R28 52 53 0.17
C28 53 0 6.8p
L28 53 54 290n
R29 54 55 0.17
C29 55 0 6.8p
L29 55 56 290n
R30 56 57 0.17
C30 57 0 6.8p
L30 57 58 290n
R31 58 59 0.17
C31 59 0 6.8p
L31 59 60 290n
R32 60 61 0.17
C32 61 0 6.8p
L32 61 62 290n
R33 62 63 0.17
C33 63 0 6.8p
L33 63 64 290n
R34 64 65 0.17
C34 65 0 6.8p
L34 65 66 290n
R35 66 67 0.17
C35 67 0 6.8p
L35 67 68 290n
R36 68 69 0.17
C36 69 0 6.8p
L36 69 70 290n
R37 70 71 0.17
C37 71 0 6.8p
L37 71 72 290n
R38 72 73 0.17
C38 73 0 6.8p
L38 73 74 290n
R39 74 75 0.17
C39 75 0 6.8p
L39 75 76 290n
R40 76 77 0.17
C40 77 0 6.8p
L40 77 78 290n
R41 78 79 0.17
C41 79 0 6.8p
L41 79 80 290n
R42 80 81 0.17
C42 81 0 6.8p
L42 81 82 290n
R43 82 83 0.17
C43 83 0 6.8p
L43 83 84 290n
R44 84 85 0.17
C44 85 0 6.8p
L44 85 86 290n
R45 86 87 0.17
C45 87 0 6.8p
L45 87 88 290n
R46 88 89 0.17
C46 89 0 6.8p
L46 89 90 290n
R47 90 91 0.17
C47 91 0 6.8p
L47 91 92 290n
R48 92 93 0.17
C48 93 0 6.8p
L48 93 94 290n
R49 94 95 0.17
C49 95 0 6.8p
L49 95 96 290n
R50 96 97 0.17
C50 97 0 6.8p
L50 97 98 290n
R51 98 99 0.17
C51 99 0 6.8p
L51 99 100 290n
R52 100 101 0.17
C52 101 0 6.8p
L52 101 102 290n
R53 102 103 0.17
C53 103 0 6.8p
L53 103 104 290n
R54 104 105 0.17
C54 105 0 6.8p
L54 105 106 290n
R55 106 107 0.17
C55 107 0 6.8p
L55 107 108 290n
R56 108 109 0.17
C56 109 0 6.8p
L56 109 110 290n
R57 110 111 0.17
C57 111 0 6.8p
L57 111 112 290n
R58 112 113 0.17
C58 113 0 6.8p
L58 113 114 290n
R59 114 115 0.17
C59 115 0 6.8p
L59 115 116 290n
R60 116 117 0.17
C60 117 0 6.8p
L60 117 118 290n
R61 118 119 0.17
C61 119 0 6.8p
L61 119 120 290n
R62 120 121 0.17
C62 121 0 6.8p
L62 121 122 290n
R63 122 123 0.17
C63 123 0 6.8p
L63 123 124 290n
R64 124 125 0.17
C64 125 0 6.8p
L64 125 126 290n
R65 126 127 0.17
C65 127 0 6.8p
L65 127 128 290n
R66 128 129 0.17
C66 129 0 6.8p
L66 129 130 290n
R67 130 131 0.17
C67 131 0 6.8p
L67 131 132 290n
R68 132 133 0.17
C68 133 0 6.8p
L68 133 134 290n
R69 134 135 0.17
C69 135 0 6.8p
L69 135 136 290n
R70 136 137 0.17
C70 137 0 6.8p
L70 137 138 290n
R71 138 139 0.17
C71 139 0 6.8p
L71 139 140 290n
R72 140 141 0.17
C72 141 0 6.8p
L72 141 142 290n
R73 142 143 0.17
C73 143 0 6.8p
L73 143 144 290n
R74 144 145 0.17
C74 145 0 6.8p
L74 145 146 290n
R75 146 147 0.17
C75 147 0 6.8p
L75 147 148 290n
R76 148 149 0.17
C76 149 0 6.8p
L76 149 150 290n
R77 150 151 0.17
C77 151 0 6.8p
L77 151 152 290n
R78 152 153 0.17
C78 153 0 6.8p
L78 153 154 290n
R79 154 155 0.17
C79 155 0 6.8p
L79 155 156 290n
R80 156 157 0.17
C80 157 0 6.8p
L80 157 158 290n
R81 158 159 0.17
C81 159 0 6.8p
L81 159 160 290n
R82 160 161 0.17
C82 161 0 6.8p
L82 161 162 290n
R83 162 163 0.17
C83 163 0 6.8p
L83 163 164 290n
R84 164 165 0.17
C84 165 0 6.8p
L84 165 166 290n
R85 166 167 0.17
C85 167 0 6.8p
L85 167 168 290n
R86 168 169 0.17
C86 169 0 6.8p
L86 169 170 290n
R87 170 171 0.17
C87 171 0 6.8p
L87 171 172 290n
R88 172 173 0.17
C88 173 0 6.8p
L88 173 174 290n
R89 174 175 0.17
C89 175 0 6.8p
L89 175 176 290n
R90 176 177 0.17
C90 177 0 6.8p
L90 177 178 290n
R91 178 179 0.17
C91 179 0 6.8p
L91 179 180 290n
R92 180 181 0.17
C92 181 0 6.8p
L92 181 182 290n
R93 182 183 0.17
C93 183 0 6.8p
L93 183 184 290n
R94 184 185 0.17
C94 185 0 6.8p
L94 185 186 290n
R95 186 187 0.17
C95 187 0 6.8p
L95 187 188 290n
R96 188 189 0.17
C96 189 0 6.8p
L96 189 190 290n
R97 190 191 0.17
C97 191 0 6.8p
L97 191 192 290n
R98 192 193 0.17
C98 193 0 6.8p
L98 193 194 290n
R99 194 195 0.17
C99 195 0 6.8p
L99 195 196 290n
R100 196 197 0.17
C100 197 0 6.8p
L100 197 198 290n
R101 198 199 0.17
C101 199 0 6.8p
L101 199 200 290n
R102 200 201 0.17
C102 201 0 6.8p
L102 201 202 290n
R103 202 203 0.17
C103 203 0 6.8p
L103 203 204 290n
R104 204 205 0.17
C104 205 0 6.8p
L104 205 206 290n
R105 206 207 0.17
C105 207 0 6.8p
L105 207 208 290n
R106 208 209 0.17
C106 209 0 6.8p
L106 209 210 290n
R107 210 211 0.17
C107 211 0 6.8p
L107 211 212 290n
R108 212 213 0.17
C108 213 0 6.8p
L108 213 214 290n
R109 214 215 0.17
C109 215 0 6.8p
L109 215 216 290n
R110 216 217 0.17
C110 217 0 6.8p
L110 217 218 290n
R111 218 219 0.17
C111 219 0 6.8p
L111 219 220 290n
R112 220 221 0.17
C112 221 0 6.8p
L112 221 222 290n
R113 222 223 0.17
C113 223 0 6.8p
L113 223 224 290n
R114 224 225 0.17
C114 225 0 6.8p
L114 225 226 290n
R115 226 227 0.17
C115 227 0 6.8p
L115 227 228 290n
R116 228 229 0.17
C116 229 0 6.8p
L116 229 230 290n
R117 230 231 0.17
C117 231 0 6.8p
L117 231 232 290n
R118 232 233 0.17
C118 233 0 6.8p
L118 233 234 290n
R119 234 235 0.17
C119 235 0 6.8p
L119 235 236 290n
R120 236 237 0.17
C120 237 0 6.8p
L120 237 238 290n
R121 238 239 0.17
C121 239 0 6.8p
L121 239 240 290n
R122 240 241 0.17
C122 241 0 6.8p
L122 241 242 290n
R123 242 243 0.17
C123 243 0 6.8p
L123 243 244 290n
R124 244 245 0.17
C124 245 0 6.8p
L124 245 246 290n
R125 246 247 0.17
C125 247 0 6.8p
L125 247 248 290n
R126 248 249 0.17
C126 249 0 6.8p
L126 249 250 290n
R127 250 251 0.17
C127 251 0 6.8p
L127 251 252 290n
R128 252 253 0.17
C128 253 0 6.8p
L128 253 254 290n
R129 254 255 0.17
C129 255 0 6.8p
L129 255 256 290n
R130 256 257 0.17
C130 257 0 6.8p
L130 257 258 290n
R131 258 259 0.17
C131 259 0 6.8p
L131 259 260 290n
R132 260 261 0.17
C132 261 0 6.8p
L132 261 262 290n
R133 262 263 0.17
C133 263 0 6.8p
L133 263 264 290n
R134 264 265 0.17
C134 265 0 6.8p
L134 265 266 290n
R135 266 267 0.17
C135 267 0 6.8p
L135 267 268 290n
R136 268 269 0.17
C136 269 0 6.8p
L136 269 270 290n
R137 270 271 0.17
C137 271 0 6.8p
L137 271 272 290n
R138 272 273 0.17
C138 273 0 6.8p
L138 273 274 290n
R139 274 275 0.17
C139 275 0 6.8p
L139 275 276 290n
R140 276 277 0.17
C140 277 0 6.8p
L140 277 278 290n
R141 278 279 0.17
C141 279 0 6.8p
L141 279 280 290n
R142 280 281 0.17
C142 281 0 6.8p
L142 281 282 290n
R143 282 283 0.17
C143 283 0 6.8p
L143 283 284 290n
R144 284 285 0.17
C144 285 0 6.8p
L144 285 286 290n
R145 286 287 0.17
C145 287 0 6.8p
L145 287 288 290n
R146 288 289 0.17
C146 289 0 6.8p
L146 289 290 290n
R147 290 291 0.17
C147 291 0 6.8p
L147 291 292 290n
R148 292 293 0.17
C148 293 0 6.8p
L148 293 294 290n
R149 294 295 0.17
C149 295 0 6.8p
L149 295 296 290n
R150 296 297 0.17
C150 297 0 6.8p
L150 297 298 290n
R151 298 299 0.17
C151 299 0 6.8p
L151 299 300 290n
R152 300 301 0.17
C152 301 0 6.8p
L152 301 302 290n
R153 302 303 0.17
C153 303 0 6.8p
L153 303 304 290n
R154 304 305 0.17
C154 305 0 6.8p
L154 305 306 290n
R155 306 307 0.17
C155 307 0 6.8p
L155 307 308 290n
R156 308 309 0.17
C156 309 0 6.8p
L156 309 310 290n
R157 310 311 0.17
C157 311 0 6.8p
L157 311 312 290n
R158 312 313 0.17
C158 313 0 6.8p
L158 313 314 290n
R159 314 315 0.17
C159 315 0 6.8p
L159 315 316 290n
R160 316 317 0.17
C160 317 0 6.8p
L160 317 318 290n
R161 318 319 0.17
C161 319 0 6.8p
L161 319 320 290n
R162 320 321 0.17
C162 321 0 6.8p
L162 321 322 290n
R163 322 323 0.17
C163 323 0 6.8p
L163 323 324 290n
R164 324 325 0.17
C164 325 0 6.8p
L164 325 326 290n
R165 326 327 0.17
C165 327 0 6.8p
L165 327 328 290n
R166 328 329 0.17
C166 329 0 6.8p
L166 329 330 290n
R167 330 331 0.17
C167 331 0 6.8p
L167 331 332 290n
R168 332 333 0.17
C168 333 0 6.8p
L168 333 334 290n
R169 334 335 0.17
C169 335 0 6.8p
L169 335 336 290n
R170 336 337 0.17
C170 337 0 6.8p
L170 337 338 290n
R171 338 339 0.17
C171 339 0 6.8p
L171 339 340 290n
R172 340 341 0.17
C172 341 0 6.8p
L172 341 342 290n
R173 342 343 0.17
C173 343 0 6.8p
L173 343 344 290n
R174 344 345 0.17
C174 345 0 6.8p
L174 345 346 290n
R175 346 347 0.17
C175 347 0 6.8p
L175 347 348 290n
R176 348 349 0.17
C176 349 0 6.8p
L176 349 350 290n
R177 350 351 0.17
C177 351 0 6.8p
L177 351 352 290n
R178 352 353 0.17
C178 353 0 6.8p
L178 353 354 290n
R179 354 355 0.17
C179 355 0 6.8p
L179 355 356 290n
R180 356 357 0.17
C180 357 0 6.8p
L180 357 358 290n
R181 358 359 0.17
C181 359 0 6.8p
L181 359 360 290n
R182 360 361 0.17
C182 361 0 6.8p
L182 361 362 290n
R183 362 363 0.17
C183 363 0 6.8p
L183 363 364 290n
R184 364 365 0.17
C184 365 0 6.8p
L184 365 366 290n
R185 366 367 0.17
C185 367 0 6.8p
L185 367 368 290n
R186 368 369 0.17
C186 369 0 6.8p
L186 369 370 290n
R187 370 371 0.17
C187 371 0 6.8p
L187 371 372 290n
R188 372 373 0.17
C188 373 0 6.8p
L188 373 374 290n
R189 374 375 0.17
C189 375 0 6.8p
L189 375 376 290n
R190 376 377 0.17
C190 377 0 6.8p
L190 377 378 290n
R191 378 379 0.17
C191 379 0 6.8p
L191 379 380 290n
R192 380 381 0.17
C192 381 0 6.8p
L192 381 382 290n
R193 382 383 0.17
C193 383 0 6.8p
L193 383 384 290n
R194 384 385 0.17
C194 385 0 6.8p
L194 385 386 290n
R195 386 387 0.17
C195 387 0 6.8p
L195 387 388 290n
R196 388 389 0.17
C196 389 0 6.8p
L196 389 390 290n
R197 390 391 0.17
C197 391 0 6.8p
L197 391 392 290n
R198 392 393 0.17
C198 393 0 6.8p
L198 393 394 290n
R199 394 395 0.17
C199 395 0 6.8p
L199 395 396 290n
R200 396 397 0.17
C200 397 0 6.8p
L200 397 398 290n
R201 398 399 0.17
C201 399 0 6.8p
L201 399 400 290n
R202 400 401 0.17
C202 401 0 6.8p
L202 401 402 290n
R203 402 403 0.17
C203 403 0 6.8p
L203 403 404 290n
R204 404 405 0.17
C204 405 0 6.8p
L204 405 406 290n
R205 406 407 0.17
C205 407 0 6.8p
L205 407 408 290n
R206 408 409 0.17
C206 409 0 6.8p
L206 409 410 290n
R207 410 411 0.17
C207 411 0 6.8p
L207 411 412 290n
R208 412 413 0.17
C208 413 0 6.8p
L208 413 414 290n
R209 414 415 0.17
C209 415 0 6.8p
L209 415 416 290n
R210 416 417 0.17
C210 417 0 6.8p
L210 417 418 290n
R211 418 419 0.17
C211 419 0 6.8p
L211 419 420 290n
R212 420 421 0.17
C212 421 0 6.8p
L212 421 422 290n
R213 422 423 0.17
C213 423 0 6.8p
L213 423 424 290n
R214 424 425 0.17
C214 425 0 6.8p
L214 425 426 290n
R215 426 427 0.17
C215 427 0 6.8p
L215 427 428 290n
R216 428 429 0.17
C216 429 0 6.8p
L216 429 430 290n
R217 430 431 0.17
C217 431 0 6.8p
L217 431 432 290n
R218 432 433 0.17
C218 433 0 6.8p
L218 433 434 290n
R219 434 435 0.17
C219 435 0 6.8p
L219 435 436 290n
R220 436 437 0.17
C220 437 0 6.8p
L220 437 438 290n
R221 438 439 0.17
C221 439 0 6.8p
L221 439 440 290n
R222 440 441 0.17
C222 441 0 6.8p
L222 441 442 290n
R223 442 443 0.17
C223 443 0 6.8p
L223 443 444 290n
R224 444 445 0.17
C224 445 0 6.8p
L224 445 446 290n
R225 446 447 0.17
C225 447 0 6.8p
L225 447 448 290n
R226 448 449 0.17
C226 449 0 6.8p
L226 449 450 290n
R227 450 451 0.17
C227 451 0 6.8p
L227 451 452 290n
R228 452 453 0.17
C228 453 0 6.8p
L228 453 454 290n
R229 454 455 0.17
C229 455 0 6.8p
L229 455 456 290n
R230 456 457 0.17
C230 457 0 6.8p
L230 457 458 290n
R231 458 459 0.17
C231 459 0 6.8p
L231 459 460 290n
R232 460 461 0.17
C232 461 0 6.8p
L232 461 462 290n
R233 462 463 0.17
C233 463 0 6.8p
L233 463 464 290n
R234 464 465 0.17
C234 465 0 6.8p
L234 465 466 290n
R235 466 467 0.17
C235 467 0 6.8p
L235 467 468 290n
R236 468 469 0.17
C236 469 0 6.8p
L236 469 470 290n
R237 470 471 0.17
C237 471 0 6.8p
L237 471 472 290n
R238 472 473 0.17
C238 473 0 6.8p
L238 473 474 290n
R239 474 475 0.17
C239 475 0 6.8p
L239 475 476 290n
R240 476 477 0.17
C240 477 0 6.8p
L240 477 478 290n
R241 478 479 0.17
C241 479 0 6.8p
L241 479 480 290n
R242 480 481 0.17
C242 481 0 6.8p
L242 481 482 290n
R243 482 483 0.17
C243 483 0 6.8p
L243 483 484 290n
R244 484 485 0.17
C244 485 0 6.8p
L244 485 486 290n
R245 486 487 0.17
C245 487 0 6.8p
L245 487 488 290n
R246 488 489 0.17
C246 489 0 6.8p
L246 489 490 290n
R247 490 491 0.17
C247 491 0 6.8p
L247 491 492 290n
R248 492 493 0.17
C248 493 0 6.8p
L248 493 494 290n
R249 494 495 0.17
C249 495 0 6.8p
L249 495 496 290n
R250 496 497 0.17
C250 497 0 6.8p
L250 497 498 290n
R251 498 499 0.17
C251 499 0 6.8p
L251 499 500 290n
R252 500 501 0.17
C252 501 0 6.8p
L252 501 502 290n
R253 502 503 0.17
C253 503 0 6.8p
L253 503 504 290n
R254 504 505 0.17
C254 505 0 6.8p
L254 505 506 290n
R255 506 507 0.17
C255 507 0 6.8p
L255 507 508 290n
R256 508 509 0.17
C256 509 0 6.8p
L256 509 510 290n
R257 510 511 0.17
C257 511 0 6.8p
L257 511 512 290n
R258 512 -1 0.17
C258 -1 0 6.8p
R259 -1 0 220
R260 -1 0 1E6
C259 -1 0 25p

.tran 600n
