*Auto-gererated 320-cell delay line circuit

I1 1 0 PWL file="C:\Users\zOob\Documents\SB REU\LTspice\data\PWL_Current_1.txt"
C2 1 0 6.8p Cpar = 0
L1 1 2 540n
R1 2 3 0.17
C3 3 0 6.8p Cpar = 0
L2 3 4 540n
R2 4 5 0.17
C4 5 0 6.8p Cpar = 0
L3 5 6 540n
R3 6 7 0.17
C5 7 0 6.8p Cpar = 0
L4 7 8 540n
R4 8 9 0.17
C6 9 0 6.8p Cpar = 0
L5 9 10 540n
R5 10 11 0.17
C7 11 0 6.8p Cpar = 0
L6 11 12 540n
R6 12 13 0.17
C8 13 0 6.8p Cpar = 0
L7 13 14 540n
R7 14 15 0.17
C9 15 0 6.8p Cpar = 0
L8 15 16 540n
R8 16 17 0.17
C10 17 0 6.8p Cpar = 0
L9 17 18 540n
R9 18 19 0.17
C11 19 0 6.8p Cpar = 0
L10 19 20 540n
R10 20 21 0.17
C12 21 0 6.8p Cpar = 0
L11 21 22 540n
R11 22 23 0.17
C13 23 0 6.8p Cpar = 0
L12 23 24 540n
R12 24 25 0.17
C14 25 0 6.8p Cpar = 0
L13 25 26 540n
R13 26 27 0.17
C15 27 0 6.8p Cpar = 0
L14 27 28 540n
R14 28 29 0.17
C16 29 0 6.8p Cpar = 0
L15 29 30 540n
R15 30 31 0.17
C17 31 0 6.8p Cpar = 0
L16 31 32 540n
R16 32 33 0.17
C18 33 0 6.8p Cpar = 0
L17 33 34 540n
R17 34 35 0.17
C19 35 0 6.8p Cpar = 0
L18 35 36 540n
R18 36 37 0.17
C20 37 0 6.8p Cpar = 0
L19 37 38 540n
R19 38 39 0.17
C21 39 0 6.8p Cpar = 0
L20 39 40 540n
R20 40 41 0.17
C22 41 0 6.8p Cpar = 0
L21 41 42 540n
R21 42 43 0.17
C23 43 0 6.8p Cpar = 0
L22 43 44 540n
R22 44 45 0.17
C24 45 0 6.8p Cpar = 0
L23 45 46 540n
R23 46 47 0.17
C25 47 0 6.8p Cpar = 0
L24 47 48 540n
R24 48 49 0.17
C26 49 0 6.8p Cpar = 0
L25 49 50 540n
R25 50 51 0.17
C27 51 0 6.8p Cpar = 0
L26 51 52 540n
R26 52 53 0.17
C28 53 0 6.8p Cpar = 0
L27 53 54 540n
R27 54 55 0.17
C29 55 0 6.8p Cpar = 0
L28 55 56 540n
R28 56 57 0.17
C30 57 0 6.8p Cpar = 0
L29 57 58 540n
R29 58 59 0.17
C31 59 0 6.8p Cpar = 0
L30 59 60 540n
R30 60 61 0.17
C32 61 0 6.8p Cpar = 0
L31 61 62 540n
R31 62 63 0.17
C33 63 0 6.8p Cpar = 0
L32 63 64 540n
R32 64 65 0.17
C34 65 0 6.8p Cpar = 0
L33 65 66 540n
R33 66 67 0.17
C35 67 0 6.8p Cpar = 0
L34 67 68 540n
R34 68 69 0.17
C36 69 0 6.8p Cpar = 0
L35 69 70 540n
R35 70 71 0.17
C37 71 0 6.8p Cpar = 0
L36 71 72 540n
R36 72 73 0.17
C38 73 0 6.8p Cpar = 0
L37 73 74 540n
R37 74 75 0.17
C39 75 0 6.8p Cpar = 0
L38 75 76 540n
R38 76 77 0.17
C40 77 0 6.8p Cpar = 0
L39 77 78 540n
R39 78 79 0.17
C41 79 0 6.8p Cpar = 0
L40 79 80 540n
R40 80 81 0.17
C42 81 0 6.8p Cpar = 0
L41 81 82 540n
R41 82 83 0.17
C43 83 0 6.8p Cpar = 0
L42 83 84 540n
R42 84 85 0.17
C44 85 0 6.8p Cpar = 0
L43 85 86 540n
R43 86 87 0.17
C45 87 0 6.8p Cpar = 0
L44 87 88 540n
R44 88 89 0.17
C46 89 0 6.8p Cpar = 0
L45 89 90 540n
R45 90 91 0.17
C47 91 0 6.8p Cpar = 0
L46 91 92 540n
R46 92 93 0.17
C48 93 0 6.8p Cpar = 0
L47 93 94 540n
R47 94 95 0.17
C49 95 0 6.8p Cpar = 0
L48 95 96 540n
R48 96 97 0.17
C50 97 0 6.8p Cpar = 0
L49 97 98 540n
R49 98 99 0.17
C51 99 0 6.8p Cpar = 0
L50 99 100 540n
R50 100 101 0.17
C52 101 0 6.8p Cpar = 0
L51 101 102 540n
R51 102 103 0.17
C53 103 0 6.8p Cpar = 0
L52 103 104 540n
R52 104 105 0.17
C54 105 0 6.8p Cpar = 0
L53 105 106 540n
R53 106 107 0.17
C55 107 0 6.8p Cpar = 0
L54 107 108 540n
R54 108 109 0.17
C56 109 0 6.8p Cpar = 0
L55 109 110 540n
R55 110 111 0.17
C57 111 0 6.8p Cpar = 0
L56 111 112 540n
R56 112 113 0.17
C58 113 0 6.8p Cpar = 0
L57 113 114 540n
R57 114 115 0.17
C59 115 0 6.8p Cpar = 0
L58 115 116 540n
R58 116 117 0.17
C60 117 0 6.8p Cpar = 0
L59 117 118 540n
R59 118 119 0.17
C61 119 0 6.8p Cpar = 0
L60 119 120 540n
R60 120 121 0.17
C62 121 0 6.8p Cpar = 0
L61 121 122 540n
R61 122 123 0.17
C63 123 0 6.8p Cpar = 0
L62 123 124 540n
R62 124 125 0.17
C64 125 0 6.8p Cpar = 0
L63 125 126 540n
R63 126 127 0.17
C65 127 0 6.8p Cpar = 0
L64 127 128 540n
R64 128 129 0.17
C66 129 0 6.8p Cpar = 0
L65 129 130 540n
R65 130 131 0.17
C67 131 0 6.8p Cpar = 0
L66 131 132 540n
R66 132 133 0.17
C68 133 0 6.8p Cpar = 0
L67 133 134 540n
R67 134 135 0.17
C69 135 0 6.8p Cpar = 0
L68 135 136 540n
R68 136 137 0.17
C70 137 0 6.8p Cpar = 0
L69 137 138 540n
R69 138 139 0.17
C71 139 0 6.8p Cpar = 0
L70 139 140 540n
R70 140 141 0.17
C72 141 0 6.8p Cpar = 0
L71 141 142 540n
R71 142 143 0.17
C73 143 0 6.8p Cpar = 0
L72 143 144 540n
R72 144 145 0.17
C74 145 0 6.8p Cpar = 0
L73 145 146 540n
R73 146 147 0.17
C75 147 0 6.8p Cpar = 0
L74 147 148 540n
R74 148 149 0.17
C76 149 0 6.8p Cpar = 0
L75 149 150 540n
R75 150 151 0.17
C77 151 0 6.8p Cpar = 0
L76 151 152 540n
R76 152 153 0.17
C78 153 0 6.8p Cpar = 0
L77 153 154 540n
R77 154 155 0.17
C79 155 0 6.8p Cpar = 0
L78 155 156 540n
R78 156 157 0.17
C80 157 0 6.8p Cpar = 0
L79 157 158 540n
R79 158 159 0.17
C81 159 0 6.8p Cpar = 0
L80 159 160 540n
R80 160 161 0.17
C82 161 0 6.8p Cpar = 0
L81 161 162 540n
R81 162 163 0.17
C83 163 0 6.8p Cpar = 0
L82 163 164 540n
R82 164 165 0.17
C84 165 0 6.8p Cpar = 0
L83 165 166 540n
R83 166 167 0.17
C85 167 0 6.8p Cpar = 0
L84 167 168 540n
R84 168 169 0.17
C86 169 0 6.8p Cpar = 0
L85 169 170 540n
R85 170 171 0.17
C87 171 0 6.8p Cpar = 0
L86 171 172 540n
R86 172 173 0.17
C88 173 0 6.8p Cpar = 0
L87 173 174 540n
R87 174 175 0.17
C89 175 0 6.8p Cpar = 0
L88 175 176 540n
R88 176 177 0.17
C90 177 0 6.8p Cpar = 0
L89 177 178 540n
R89 178 179 0.17
C91 179 0 6.8p Cpar = 0
L90 179 180 540n
R90 180 181 0.17
C92 181 0 6.8p Cpar = 0
L91 181 182 540n
R91 182 183 0.17
C93 183 0 6.8p Cpar = 0
L92 183 184 540n
R92 184 185 0.17
C94 185 0 6.8p Cpar = 0
L93 185 186 540n
R93 186 187 0.17
C95 187 0 6.8p Cpar = 0
L94 187 188 540n
R94 188 189 0.17
C96 189 0 6.8p Cpar = 0
L95 189 190 540n
R95 190 191 0.17
C97 191 0 6.8p Cpar = 0
L96 191 192 540n
R96 192 193 0.17
C98 193 0 6.8p Cpar = 0
L97 193 194 540n
R97 194 195 0.17
C99 195 0 6.8p Cpar = 0
L98 195 196 540n
R98 196 197 0.17
C100 197 0 6.8p Cpar = 0
L99 197 198 540n
R99 198 199 0.17
C101 199 0 6.8p Cpar = 0
L100 199 200 540n
R100 200 201 0.17
C102 201 0 6.8p Cpar = 0
L101 201 202 540n
R101 202 203 0.17
C103 203 0 6.8p Cpar = 0
L102 203 204 540n
R102 204 205 0.17
C104 205 0 6.8p Cpar = 0
L103 205 206 540n
R103 206 207 0.17
C105 207 0 6.8p Cpar = 0
L104 207 208 540n
R104 208 209 0.17
C106 209 0 6.8p Cpar = 0
L105 209 210 540n
R105 210 211 0.17
C107 211 0 6.8p Cpar = 0
L106 211 212 540n
R106 212 213 0.17
C108 213 0 6.8p Cpar = 0
L107 213 214 540n
R107 214 215 0.17
C109 215 0 6.8p Cpar = 0
L108 215 216 540n
R108 216 217 0.17
C110 217 0 6.8p Cpar = 0
L109 217 218 540n
R109 218 219 0.17
C111 219 0 6.8p Cpar = 0
L110 219 220 540n
R110 220 221 0.17
C112 221 0 6.8p Cpar = 0
L111 221 222 540n
R111 222 223 0.17
C113 223 0 6.8p Cpar = 0
L112 223 224 540n
R112 224 225 0.17
C114 225 0 6.8p Cpar = 0
L113 225 226 540n
R113 226 227 0.17
C115 227 0 6.8p Cpar = 0
L114 227 228 540n
R114 228 229 0.17
C116 229 0 6.8p Cpar = 0
L115 229 230 540n
R115 230 231 0.17
C117 231 0 6.8p Cpar = 0
L116 231 232 540n
R116 232 233 0.17
C118 233 0 6.8p Cpar = 0
L117 233 234 540n
R117 234 235 0.17
C119 235 0 6.8p Cpar = 0
L118 235 236 540n
R118 236 237 0.17
C120 237 0 6.8p Cpar = 0
L119 237 238 540n
R119 238 239 0.17
C121 239 0 6.8p Cpar = 0
L120 239 240 540n
R120 240 241 0.17
C122 241 0 6.8p Cpar = 0
L121 241 242 540n
R121 242 243 0.17
C123 243 0 6.8p Cpar = 0
L122 243 244 540n
R122 244 245 0.17
C124 245 0 6.8p Cpar = 0
L123 245 246 540n
R123 246 247 0.17
C125 247 0 6.8p Cpar = 0
L124 247 248 540n
R124 248 249 0.17
C126 249 0 6.8p Cpar = 0
L125 249 250 540n
R125 250 251 0.17
C127 251 0 6.8p Cpar = 0
L126 251 252 540n
R126 252 253 0.17
C128 253 0 6.8p Cpar = 0
L127 253 254 540n
R127 254 255 0.17
C129 255 0 6.8p Cpar = 0
L128 255 256 540n
R128 256 257 0.17
C130 257 0 6.8p Cpar = 0
L129 257 258 540n
R129 258 259 0.17
C131 259 0 6.8p Cpar = 0
L130 259 260 540n
R130 260 261 0.17
C132 261 0 6.8p Cpar = 0
L131 261 262 540n
R131 262 263 0.17
C133 263 0 6.8p Cpar = 0
L132 263 264 540n
R132 264 265 0.17
C134 265 0 6.8p Cpar = 0
L133 265 266 540n
R133 266 267 0.17
C135 267 0 6.8p Cpar = 0
L134 267 268 540n
R134 268 269 0.17
C136 269 0 6.8p Cpar = 0
L135 269 270 540n
R135 270 271 0.17
C137 271 0 6.8p Cpar = 0
L136 271 272 540n
R136 272 273 0.17
C138 273 0 6.8p Cpar = 0
L137 273 274 540n
R137 274 275 0.17
C139 275 0 6.8p Cpar = 0
L138 275 276 540n
R138 276 277 0.17
C140 277 0 6.8p Cpar = 0
L139 277 278 540n
R139 278 279 0.17
C141 279 0 6.8p Cpar = 0
L140 279 280 540n
R140 280 281 0.17
C142 281 0 6.8p Cpar = 0
L141 281 282 540n
R141 282 283 0.17
C143 283 0 6.8p Cpar = 0
L142 283 284 540n
R142 284 285 0.17
C144 285 0 6.8p Cpar = 0
L143 285 286 540n
R143 286 287 0.17
C145 287 0 6.8p Cpar = 0
L144 287 288 540n
R144 288 289 0.17
C146 289 0 6.8p Cpar = 0
L145 289 290 540n
R145 290 291 0.17
C147 291 0 6.8p Cpar = 0
L146 291 292 540n
R146 292 293 0.17
C148 293 0 6.8p Cpar = 0
L147 293 294 540n
R147 294 295 0.17
C149 295 0 6.8p Cpar = 0
L148 295 296 540n
R148 296 297 0.17
C150 297 0 6.8p Cpar = 0
L149 297 298 540n
R149 298 299 0.17
C151 299 0 6.8p Cpar = 0
L150 299 300 540n
R150 300 301 0.17
C152 301 0 6.8p Cpar = 0
L151 301 302 540n
R151 302 303 0.17
C153 303 0 6.8p Cpar = 0
L152 303 304 540n
R152 304 305 0.17
C154 305 0 6.8p Cpar = 0
L153 305 306 540n
R153 306 307 0.17
C155 307 0 6.8p Cpar = 0
L154 307 308 540n
R154 308 309 0.17
C156 309 0 6.8p Cpar = 0
L155 309 310 540n
R155 310 311 0.17
C157 311 0 6.8p Cpar = 0
L156 311 312 540n
R156 312 313 0.17
C158 313 0 6.8p Cpar = 0
L157 313 314 540n
R157 314 315 0.17
C159 315 0 6.8p Cpar = 0
L158 315 316 540n
R158 316 317 0.17
C160 317 0 6.8p Cpar = 0
L159 317 318 540n
R159 318 319 0.17
C161 319 0 6.8p Cpar = 0
L160 319 320 540n
R160 320 321 0.17
C162 321 0 6.8p Cpar = 0
L161 321 322 540n
R161 322 323 0.17
C163 323 0 6.8p Cpar = 0
L162 323 324 540n
R162 324 325 0.17
C164 325 0 6.8p Cpar = 0
L163 325 326 540n
R163 326 327 0.17
C165 327 0 6.8p Cpar = 0
L164 327 328 540n
R164 328 329 0.17
C166 329 0 6.8p Cpar = 0
L165 329 330 540n
R165 330 331 0.17
C167 331 0 6.8p Cpar = 0
L166 331 332 540n
R166 332 333 0.17
C168 333 0 6.8p Cpar = 0
L167 333 334 540n
R167 334 335 0.17
C169 335 0 6.8p Cpar = 0
L168 335 336 540n
R168 336 337 0.17
C170 337 0 6.8p Cpar = 0
L169 337 338 540n
R169 338 339 0.17
C171 339 0 6.8p Cpar = 0
L170 339 340 540n
R170 340 341 0.17
C172 341 0 6.8p Cpar = 0
L171 341 342 540n
R171 342 343 0.17
C173 343 0 6.8p Cpar = 0
L172 343 344 540n
R172 344 345 0.17
C174 345 0 6.8p Cpar = 0
L173 345 346 540n
R173 346 347 0.17
C175 347 0 6.8p Cpar = 0
L174 347 348 540n
R174 348 349 0.17
C176 349 0 6.8p Cpar = 0
L175 349 350 540n
R175 350 351 0.17
C177 351 0 6.8p Cpar = 0
L176 351 352 540n
R176 352 353 0.17
C178 353 0 6.8p Cpar = 0
L177 353 354 540n
R177 354 355 0.17
C179 355 0 6.8p Cpar = 0
L178 355 356 540n
R178 356 357 0.17
C180 357 0 6.8p Cpar = 0
L179 357 358 540n
R179 358 359 0.17
C181 359 0 6.8p Cpar = 0
L180 359 360 540n
R180 360 361 0.17
C182 361 0 6.8p Cpar = 0
L181 361 362 540n
R181 362 363 0.17
C183 363 0 6.8p Cpar = 0
L182 363 364 540n
R182 364 365 0.17
C184 365 0 6.8p Cpar = 0
L183 365 366 540n
R183 366 367 0.17
C185 367 0 6.8p Cpar = 0
L184 367 368 540n
R184 368 369 0.17
C186 369 0 6.8p Cpar = 0
L185 369 370 540n
R185 370 371 0.17
C187 371 0 6.8p Cpar = 0
L186 371 372 540n
R186 372 373 0.17
C188 373 0 6.8p Cpar = 0
L187 373 374 540n
R187 374 375 0.17
C189 375 0 6.8p Cpar = 0
L188 375 376 540n
R188 376 377 0.17
C190 377 0 6.8p Cpar = 0
L189 377 378 540n
R189 378 379 0.17
C191 379 0 6.8p Cpar = 0
L190 379 380 540n
R190 380 381 0.17
C192 381 0 6.8p Cpar = 0
L191 381 382 540n
R191 382 383 0.17
C193 383 0 6.8p Cpar = 0
L192 383 384 540n
R192 384 385 0.17
C194 385 0 6.8p Cpar = 0
L193 385 386 540n
R193 386 387 0.17
C195 387 0 6.8p Cpar = 0
L194 387 388 540n
R194 388 389 0.17
C196 389 0 6.8p Cpar = 0
L195 389 390 540n
R195 390 391 0.17
C197 391 0 6.8p Cpar = 0
L196 391 392 540n
R196 392 393 0.17
C198 393 0 6.8p Cpar = 0
L197 393 394 540n
R197 394 395 0.17
C199 395 0 6.8p Cpar = 0
L198 395 396 540n
R198 396 397 0.17
C200 397 0 6.8p Cpar = 0
L199 397 398 540n
R199 398 399 0.17
C201 399 0 6.8p Cpar = 0
L200 399 400 540n
R200 400 401 0.17
C202 401 0 6.8p Cpar = 0
L201 401 402 540n
R201 402 403 0.17
C203 403 0 6.8p Cpar = 0
L202 403 404 540n
R202 404 405 0.17
C204 405 0 6.8p Cpar = 0
L203 405 406 540n
R203 406 407 0.17
C205 407 0 6.8p Cpar = 0
L204 407 408 540n
R204 408 409 0.17
C206 409 0 6.8p Cpar = 0
L205 409 410 540n
R205 410 411 0.17
C207 411 0 6.8p Cpar = 0
L206 411 412 540n
R206 412 413 0.17
C208 413 0 6.8p Cpar = 0
L207 413 414 540n
R207 414 415 0.17
C209 415 0 6.8p Cpar = 0
L208 415 416 540n
R208 416 417 0.17
C210 417 0 6.8p Cpar = 0
L209 417 418 540n
R209 418 419 0.17
C211 419 0 6.8p Cpar = 0
L210 419 420 540n
R210 420 421 0.17
C212 421 0 6.8p Cpar = 0
L211 421 422 540n
R211 422 423 0.17
C213 423 0 6.8p Cpar = 0
L212 423 424 540n
R212 424 425 0.17
C214 425 0 6.8p Cpar = 0
L213 425 426 540n
R213 426 427 0.17
C215 427 0 6.8p Cpar = 0
L214 427 428 540n
R214 428 429 0.17
C216 429 0 6.8p Cpar = 0
L215 429 430 540n
R215 430 431 0.17
C217 431 0 6.8p Cpar = 0
L216 431 432 540n
R216 432 433 0.17
C218 433 0 6.8p Cpar = 0
L217 433 434 540n
R217 434 435 0.17
C219 435 0 6.8p Cpar = 0
L218 435 436 540n
R218 436 437 0.17
C220 437 0 6.8p Cpar = 0
L219 437 438 540n
R219 438 439 0.17
C221 439 0 6.8p Cpar = 0
L220 439 440 540n
R220 440 441 0.17
C222 441 0 6.8p Cpar = 0
L221 441 442 540n
R221 442 443 0.17
C223 443 0 6.8p Cpar = 0
L222 443 444 540n
R222 444 445 0.17
C224 445 0 6.8p Cpar = 0
L223 445 446 540n
R223 446 447 0.17
C225 447 0 6.8p Cpar = 0
L224 447 448 540n
R224 448 449 0.17
C226 449 0 6.8p Cpar = 0
L225 449 450 540n
R225 450 451 0.17
C227 451 0 6.8p Cpar = 0
L226 451 452 540n
R226 452 453 0.17
C228 453 0 6.8p Cpar = 0
L227 453 454 540n
R227 454 455 0.17
C229 455 0 6.8p Cpar = 0
L228 455 456 540n
R228 456 457 0.17
C230 457 0 6.8p Cpar = 0
L229 457 458 540n
R229 458 459 0.17
C231 459 0 6.8p Cpar = 0
L230 459 460 540n
R230 460 461 0.17
C232 461 0 6.8p Cpar = 0
L231 461 462 540n
R231 462 463 0.17
C233 463 0 6.8p Cpar = 0
L232 463 464 540n
R232 464 465 0.17
C234 465 0 6.8p Cpar = 0
L233 465 466 540n
R233 466 467 0.17
C235 467 0 6.8p Cpar = 0
L234 467 468 540n
R234 468 469 0.17
C236 469 0 6.8p Cpar = 0
L235 469 470 540n
R235 470 471 0.17
C237 471 0 6.8p Cpar = 0
L236 471 472 540n
R236 472 473 0.17
C238 473 0 6.8p Cpar = 0
L237 473 474 540n
R237 474 475 0.17
C239 475 0 6.8p Cpar = 0
L238 475 476 540n
R238 476 477 0.17
C240 477 0 6.8p Cpar = 0
L239 477 478 540n
R239 478 479 0.17
C241 479 0 6.8p Cpar = 0
L240 479 480 540n
R240 480 481 0.17
C242 481 0 6.8p Cpar = 0
L241 481 482 540n
R241 482 483 0.17
C243 483 0 6.8p Cpar = 0
L242 483 484 540n
R242 484 485 0.17
C244 485 0 6.8p Cpar = 0
L243 485 486 540n
R243 486 487 0.17
C245 487 0 6.8p Cpar = 0
L244 487 488 540n
R244 488 489 0.17
C246 489 0 6.8p Cpar = 0
L245 489 490 540n
R245 490 491 0.17
C247 491 0 6.8p Cpar = 0
L246 491 492 540n
R246 492 493 0.17
C248 493 0 6.8p Cpar = 0
L247 493 494 540n
R247 494 495 0.17
C249 495 0 6.8p Cpar = 0
L248 495 496 540n
R248 496 497 0.17
C250 497 0 6.8p Cpar = 0
L249 497 498 540n
R249 498 499 0.17
C251 499 0 6.8p Cpar = 0
L250 499 500 540n
R250 500 501 0.17
C252 501 0 6.8p Cpar = 0
L251 501 502 540n
R251 502 503 0.17
C253 503 0 6.8p Cpar = 0
L252 503 504 540n
R252 504 505 0.17
C254 505 0 6.8p Cpar = 0
L253 505 506 540n
R253 506 507 0.17
C255 507 0 6.8p Cpar = 0
L254 507 508 540n
R254 508 509 0.17
C256 509 0 6.8p Cpar = 0
L255 509 510 540n
R255 510 511 0.17
C257 511 0 6.8p Cpar = 0
L256 511 512 540n
R256 512 513 0.17
C258 513 0 6.8p Cpar = 0
L257 513 514 540n
R257 514 515 0.17
C259 515 0 6.8p Cpar = 0
L258 515 516 540n
R258 516 517 0.17
C260 517 0 6.8p Cpar = 0
L259 517 518 540n
R259 518 519 0.17
C261 519 0 6.8p Cpar = 0
L260 519 520 540n
R260 520 521 0.17
C262 521 0 6.8p Cpar = 0
L261 521 522 540n
R261 522 523 0.17
C263 523 0 6.8p Cpar = 0
L262 523 524 540n
R262 524 525 0.17
C264 525 0 6.8p Cpar = 0
L263 525 526 540n
R263 526 527 0.17
C265 527 0 6.8p Cpar = 0
L264 527 528 540n
R264 528 529 0.17
C266 529 0 6.8p Cpar = 0
L265 529 530 540n
R265 530 531 0.17
C267 531 0 6.8p Cpar = 0
L266 531 532 540n
R266 532 533 0.17
C268 533 0 6.8p Cpar = 0
L267 533 534 540n
R267 534 535 0.17
C269 535 0 6.8p Cpar = 0
L268 535 536 540n
R268 536 537 0.17
C270 537 0 6.8p Cpar = 0
L269 537 538 540n
R269 538 539 0.17
C271 539 0 6.8p Cpar = 0
L270 539 540 540n
R270 540 541 0.17
C272 541 0 6.8p Cpar = 0
L271 541 542 540n
R271 542 543 0.17
C273 543 0 6.8p Cpar = 0
L272 543 544 540n
R272 544 545 0.17
C274 545 0 6.8p Cpar = 0
L273 545 546 540n
R273 546 547 0.17
C275 547 0 6.8p Cpar = 0
L274 547 548 540n
R274 548 549 0.17
C276 549 0 6.8p Cpar = 0
L275 549 550 540n
R275 550 551 0.17
C277 551 0 6.8p Cpar = 0
L276 551 552 540n
R276 552 553 0.17
C278 553 0 6.8p Cpar = 0
L277 553 554 540n
R277 554 555 0.17
C279 555 0 6.8p Cpar = 0
L278 555 556 540n
R278 556 557 0.17
C280 557 0 6.8p Cpar = 0
L279 557 558 540n
R279 558 559 0.17
C281 559 0 6.8p Cpar = 0
L280 559 560 540n
R280 560 561 0.17
C282 561 0 6.8p Cpar = 0
L281 561 562 540n
R281 562 563 0.17
C283 563 0 6.8p Cpar = 0
L282 563 564 540n
R282 564 565 0.17
C284 565 0 6.8p Cpar = 0
L283 565 566 540n
R283 566 567 0.17
C285 567 0 6.8p Cpar = 0
L284 567 568 540n
R284 568 569 0.17
C286 569 0 6.8p Cpar = 0
L285 569 570 540n
R285 570 571 0.17
C287 571 0 6.8p Cpar = 0
L286 571 572 540n
R286 572 573 0.17
C288 573 0 6.8p Cpar = 0
L287 573 574 540n
R287 574 575 0.17
C289 575 0 6.8p Cpar = 0
L288 575 576 540n
R288 576 577 0.17
C290 577 0 6.8p Cpar = 0
L289 577 578 540n
R289 578 579 0.17
C291 579 0 6.8p Cpar = 0
L290 579 580 540n
R290 580 581 0.17
C292 581 0 6.8p Cpar = 0
L291 581 582 540n
R291 582 583 0.17
C293 583 0 6.8p Cpar = 0
L292 583 584 540n
R292 584 585 0.17
C294 585 0 6.8p Cpar = 0
L293 585 586 540n
R293 586 587 0.17
C295 587 0 6.8p Cpar = 0
L294 587 588 540n
R294 588 589 0.17
C296 589 0 6.8p Cpar = 0
L295 589 590 540n
R295 590 591 0.17
C297 591 0 6.8p Cpar = 0
L296 591 592 540n
R296 592 593 0.17
C298 593 0 6.8p Cpar = 0
L297 593 594 540n
R297 594 595 0.17
C299 595 0 6.8p Cpar = 0
L298 595 596 540n
R298 596 597 0.17
C300 597 0 6.8p Cpar = 0
L299 597 598 540n
R299 598 599 0.17
C301 599 0 6.8p Cpar = 0
L300 599 600 540n
R300 600 601 0.17
C302 601 0 6.8p Cpar = 0
L301 601 602 540n
R301 602 603 0.17
C303 603 0 6.8p Cpar = 0
L302 603 604 540n
R302 604 605 0.17
C304 605 0 6.8p Cpar = 0
L303 605 606 540n
R303 606 607 0.17
C305 607 0 6.8p Cpar = 0
L304 607 608 540n
R304 608 609 0.17
C306 609 0 6.8p Cpar = 0
L305 609 610 540n
R305 610 611 0.17
C307 611 0 6.8p Cpar = 0
L306 611 612 540n
R306 612 613 0.17
C308 613 0 6.8p Cpar = 0
L307 613 614 540n
R307 614 615 0.17
C309 615 0 6.8p Cpar = 0
L308 615 616 540n
R308 616 617 0.17
C310 617 0 6.8p Cpar = 0
L309 617 618 540n
R309 618 619 0.17
C311 619 0 6.8p Cpar = 0
L310 619 620 540n
R310 620 621 0.17
C312 621 0 6.8p Cpar = 0
L311 621 622 540n
R311 622 623 0.17
C313 623 0 6.8p Cpar = 0
L312 623 624 540n
R312 624 625 0.17
C314 625 0 6.8p Cpar = 0
L313 625 626 540n
R313 626 627 0.17
C315 627 0 6.8p Cpar = 0
L314 627 628 540n
R314 628 629 0.17
C316 629 0 6.8p Cpar = 0
L315 629 630 540n
R315 630 631 0.17
C317 631 0 6.8p Cpar = 0
L316 631 632 540n
R316 632 633 0.17
C318 633 0 6.8p Cpar = 0
L317 633 634 540n
R317 634 635 0.17
C319 635 0 6.8p Cpar = 0
L318 635 636 540n
R318 636 637 0.17
C320 637 0 6.8p Cpar = 0
L319 637 638 540n
R319 638 639 0.17
C321 639 0 6.8p Cpar = 0
L320 639 640 540n
R320 640 -1 0.17
C322 -1 0 6.8p Cpar = 0
R321 -1 0 285

.tran 900n
