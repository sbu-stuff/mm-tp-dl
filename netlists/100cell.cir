*Auto-gererated 100-cell delay line circuit

V1 1 0 PULSE(0 1 0 7.5n 7.5n 100n 1 1)
R1 1 0 220
C2 1 0 6.8p Cpar = 0
L2 1 2 290n
R3 2 3 0.17
C3 3 0 6.8p Cpar = 0
L3 3 4 290n
R4 4 5 0.17
C4 5 0 6.8p Cpar = 0
L4 5 6 290n
R5 6 7 0.17
C5 7 0 6.8p Cpar = 0
L5 7 8 290n
R6 8 9 0.17
C6 9 0 6.8p Cpar = 0
L6 9 10 290n
R7 10 11 0.17
C7 11 0 6.8p Cpar = 0
L7 11 12 290n
R8 12 13 0.17
C8 13 0 6.8p Cpar = 0
L8 13 14 290n
R9 14 15 0.17
C9 15 0 6.8p Cpar = 0
L9 15 16 290n
R10 16 17 0.17
C10 17 0 6.8p Cpar = 0
L10 17 18 290n
R11 18 19 0.17
C11 19 0 6.8p Cpar = 0
L11 19 20 290n
R12 20 21 0.17
C12 21 0 6.8p Cpar = 0
L12 21 22 290n
R13 22 23 0.17
C13 23 0 6.8p Cpar = 0
L13 23 24 290n
R14 24 25 0.17
C14 25 0 6.8p Cpar = 0
L14 25 26 290n
R15 26 27 0.17
C15 27 0 6.8p Cpar = 0
L15 27 28 290n
R16 28 29 0.17
C16 29 0 6.8p Cpar = 0
L16 29 30 290n
R17 30 31 0.17
C17 31 0 6.8p Cpar = 0
L17 31 32 290n
R18 32 33 0.17
C18 33 0 6.8p Cpar = 0
L18 33 34 290n
R19 34 35 0.17
C19 35 0 6.8p Cpar = 0
L19 35 36 290n
R20 36 37 0.17
C20 37 0 6.8p Cpar = 0
L20 37 38 290n
R21 38 39 0.17
C21 39 0 6.8p Cpar = 0
L21 39 40 290n
R22 40 41 0.17
C22 41 0 6.8p Cpar = 0
L22 41 42 290n
R23 42 43 0.17
C23 43 0 6.8p Cpar = 0
L23 43 44 290n
R24 44 45 0.17
C24 45 0 6.8p Cpar = 0
L24 45 46 290n
R25 46 47 0.17
C25 47 0 6.8p Cpar = 0
L25 47 48 290n
R26 48 49 0.17
C26 49 0 6.8p Cpar = 0
L26 49 50 290n
R27 50 51 0.17
C27 51 0 6.8p Cpar = 0
L27 51 52 290n
R28 52 53 0.17
C28 53 0 6.8p Cpar = 0
L28 53 54 290n
R29 54 55 0.17
C29 55 0 6.8p Cpar = 0
L29 55 56 290n
R30 56 57 0.17
C30 57 0 6.8p Cpar = 0
L30 57 58 290n
R31 58 59 0.17
C31 59 0 6.8p Cpar = 0
L31 59 60 290n
R32 60 61 0.17
C32 61 0 6.8p Cpar = 0
L32 61 62 290n
R33 62 63 0.17
C33 63 0 6.8p Cpar = 0
L33 63 64 290n
R34 64 65 0.17
C34 65 0 6.8p Cpar = 0
L34 65 66 290n
R35 66 67 0.17
C35 67 0 6.8p Cpar = 0
L35 67 68 290n
R36 68 69 0.17
C36 69 0 6.8p Cpar = 0
L36 69 70 290n
R37 70 71 0.17
C37 71 0 6.8p Cpar = 0
L37 71 72 290n
R38 72 73 0.17
C38 73 0 6.8p Cpar = 0
L38 73 74 290n
R39 74 75 0.17
C39 75 0 6.8p Cpar = 0
L39 75 76 290n
R40 76 77 0.17
C40 77 0 6.8p Cpar = 0
L40 77 78 290n
R41 78 79 0.17
C41 79 0 6.8p Cpar = 0
L41 79 80 290n
R42 80 81 0.17
C42 81 0 6.8p Cpar = 0
L42 81 82 290n
R43 82 83 0.17
C43 83 0 6.8p Cpar = 0
L43 83 84 290n
R44 84 85 0.17
C44 85 0 6.8p Cpar = 0
L44 85 86 290n
R45 86 87 0.17
C45 87 0 6.8p Cpar = 0
L45 87 88 290n
R46 88 89 0.17
C46 89 0 6.8p Cpar = 0
L46 89 90 290n
R47 90 91 0.17
C47 91 0 6.8p Cpar = 0
L47 91 92 290n
R48 92 93 0.17
C48 93 0 6.8p Cpar = 0
L48 93 94 290n
R49 94 95 0.17
C49 95 0 6.8p Cpar = 0
L49 95 96 290n
R50 96 97 0.17
C50 97 0 6.8p Cpar = 0
L50 97 98 290n
R51 98 99 0.17
C51 99 0 6.8p Cpar = 0
L51 99 100 290n
R52 100 101 0.17
C52 101 0 6.8p Cpar = 0
L52 101 102 290n
R53 102 103 0.17
C53 103 0 6.8p Cpar = 0
L53 103 104 290n
R54 104 105 0.17
C54 105 0 6.8p Cpar = 0
L54 105 106 290n
R55 106 107 0.17
C55 107 0 6.8p Cpar = 0
L55 107 108 290n
R56 108 109 0.17
C56 109 0 6.8p Cpar = 0
L56 109 110 290n
R57 110 111 0.17
C57 111 0 6.8p Cpar = 0
L57 111 112 290n
R58 112 113 0.17
C58 113 0 6.8p Cpar = 0
L58 113 114 290n
R59 114 115 0.17
C59 115 0 6.8p Cpar = 0
L59 115 116 290n
R60 116 117 0.17
C60 117 0 6.8p Cpar = 0
L60 117 118 290n
R61 118 119 0.17
C61 119 0 6.8p Cpar = 0
L61 119 120 290n
R62 120 121 0.17
C62 121 0 6.8p Cpar = 0
L62 121 122 290n
R63 122 123 0.17
C63 123 0 6.8p Cpar = 0
L63 123 124 290n
R64 124 125 0.17
C64 125 0 6.8p Cpar = 0
L64 125 126 290n
R65 126 127 0.17
C65 127 0 6.8p Cpar = 0
L65 127 128 290n
R66 128 129 0.17
C66 129 0 6.8p Cpar = 0
L66 129 130 290n
R67 130 131 0.17
C67 131 0 6.8p Cpar = 0
L67 131 132 290n
R68 132 133 0.17
C68 133 0 6.8p Cpar = 0
L68 133 134 290n
R69 134 135 0.17
C69 135 0 6.8p Cpar = 0
L69 135 136 290n
R70 136 137 0.17
C70 137 0 6.8p Cpar = 0
L70 137 138 290n
R71 138 139 0.17
C71 139 0 6.8p Cpar = 0
L71 139 140 290n
R72 140 141 0.17
C72 141 0 6.8p Cpar = 0
L72 141 142 290n
R73 142 143 0.17
C73 143 0 6.8p Cpar = 0
L73 143 144 290n
R74 144 145 0.17
C74 145 0 6.8p Cpar = 0
L74 145 146 290n
R75 146 147 0.17
C75 147 0 6.8p Cpar = 0
L75 147 148 290n
R76 148 149 0.17
C76 149 0 6.8p Cpar = 0
L76 149 150 290n
R77 150 151 0.17
C77 151 0 6.8p Cpar = 0
L77 151 152 290n
R78 152 153 0.17
C78 153 0 6.8p Cpar = 0
L78 153 154 290n
R79 154 155 0.17
C79 155 0 6.8p Cpar = 0
L79 155 156 290n
R80 156 157 0.17
C80 157 0 6.8p Cpar = 0
L80 157 158 290n
R81 158 159 0.17
C81 159 0 6.8p Cpar = 0
L81 159 160 290n
R82 160 161 0.17
C82 161 0 6.8p Cpar = 0
L82 161 162 290n
R83 162 163 0.17
C83 163 0 6.8p Cpar = 0
L83 163 164 290n
R84 164 165 0.17
C84 165 0 6.8p Cpar = 0
L84 165 166 290n
R85 166 167 0.17
C85 167 0 6.8p Cpar = 0
L85 167 168 290n
R86 168 169 0.17
C86 169 0 6.8p Cpar = 0
L86 169 170 290n
R87 170 171 0.17
C87 171 0 6.8p Cpar = 0
L87 171 172 290n
R88 172 173 0.17
C88 173 0 6.8p Cpar = 0
L88 173 174 290n
R89 174 175 0.17
C89 175 0 6.8p Cpar = 0
L89 175 176 290n
R90 176 177 0.17
C90 177 0 6.8p Cpar = 0
L90 177 178 290n
R91 178 179 0.17
C91 179 0 6.8p Cpar = 0
L91 179 180 290n
R92 180 181 0.17
C92 181 0 6.8p Cpar = 0
L92 181 182 290n
R93 182 183 0.17
C93 183 0 6.8p Cpar = 0
L93 183 184 290n
R94 184 185 0.17
C94 185 0 6.8p Cpar = 0
L94 185 186 290n
R95 186 187 0.17
C95 187 0 6.8p Cpar = 0
L95 187 188 290n
R96 188 189 0.17
C96 189 0 6.8p Cpar = 0
L96 189 190 290n
R97 190 191 0.17
C97 191 0 6.8p Cpar = 0
L97 191 192 290n
R98 192 193 0.17
C98 193 0 6.8p Cpar = 0
L98 193 194 290n
R99 194 195 0.17
C99 195 0 6.8p Cpar = 0
L99 195 196 290n
R100 196 197 0.17
C100 197 0 6.8p Cpar = 0
L100 197 198 290n
R101 198 199 0.17
C101 199 0 6.8p Cpar = 0
L101 199 200 290n
R102 200 -1 0.17
C102 -1 0 6.8p Cpar = 0
R103 -1 0 220

.tran 357n
