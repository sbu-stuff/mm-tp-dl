*test netlist

V1 1 0 12
R1 1 2 10
R2 1 3 20
R3 2 3 7.5
R4 2 0 30
R5 3 0 5

*DC analysis
.op
