*Auto-gererated 64-cell delay line circuit

V1 1 0 PULSE(0 1 0 7.5n 7.5n 100n 1 1)
C2 1 0 6.8p Cpar = 0
L2 1 2 300u
R2 2 3 0.17
C3 3 0 6.8p Cpar = 0
L3 3 4 300u
R3 4 5 0.17
C4 5 0 6.8p Cpar = 0
L4 5 6 300u
R4 6 7 0.17
C5 7 0 6.8p Cpar = 0
L5 7 8 300u
R5 8 9 0.17
C6 9 0 6.8p Cpar = 0
L6 9 10 300u
R6 10 11 0.17
C7 11 0 6.8p Cpar = 0
L7 11 12 300u
R7 12 13 0.17
C8 13 0 6.8p Cpar = 0
L8 13 14 300u
R8 14 15 0.17
C9 15 0 6.8p Cpar = 0
L9 15 16 300u
R9 16 17 0.17
C10 17 0 6.8p Cpar = 0
L10 17 18 300u
R10 18 19 0.17
C11 19 0 6.8p Cpar = 0
L11 19 20 300u
R11 20 21 0.17
C12 21 0 6.8p Cpar = 0
L12 21 22 300u
R12 22 23 0.17
C13 23 0 6.8p Cpar = 0
L13 23 24 300u
R13 24 25 0.17
C14 25 0 6.8p Cpar = 0
L14 25 26 300u
R14 26 27 0.17
C15 27 0 6.8p Cpar = 0
L15 27 28 300u
R15 28 29 0.17
C16 29 0 6.8p Cpar = 0
L16 29 30 300u
R16 30 31 0.17
C17 31 0 6.8p Cpar = 0
L17 31 32 300u
R17 32 33 0.17
C18 33 0 6.8p Cpar = 0
L18 33 34 300u
R18 34 35 0.17
C19 35 0 6.8p Cpar = 0
L19 35 36 300u
R19 36 37 0.17
C20 37 0 6.8p Cpar = 0
L20 37 38 300u
R20 38 39 0.17
C21 39 0 6.8p Cpar = 0
L21 39 40 300u
R21 40 41 0.17
C22 41 0 6.8p Cpar = 0
L22 41 42 300u
R22 42 43 0.17
C23 43 0 6.8p Cpar = 0
L23 43 44 300u
R23 44 45 0.17
C24 45 0 6.8p Cpar = 0
L24 45 46 300u
R24 46 47 0.17
C25 47 0 6.8p Cpar = 0
L25 47 48 300u
R25 48 49 0.17
C26 49 0 6.8p Cpar = 0
L26 49 50 300u
R26 50 51 0.17
C27 51 0 6.8p Cpar = 0
L27 51 52 300u
R27 52 53 0.17
C28 53 0 6.8p Cpar = 0
L28 53 54 300u
R28 54 55 0.17
C29 55 0 6.8p Cpar = 0
L29 55 56 300u
R29 56 57 0.17
C30 57 0 6.8p Cpar = 0
L30 57 58 300u
R30 58 59 0.17
C31 59 0 6.8p Cpar = 0
L31 59 60 300u
R31 60 61 0.17
C32 61 0 6.8p Cpar = 0
L32 61 62 300u
R32 62 63 0.17
C33 63 0 6.8p Cpar = 0
L33 63 64 300u
R33 64 65 0.17
C34 65 0 6.8p Cpar = 0
L34 65 66 300u
R34 66 67 0.17
C35 67 0 6.8p Cpar = 0
L35 67 68 300u
R35 68 69 0.17
C36 69 0 6.8p Cpar = 0
L36 69 70 300u
R36 70 71 0.17
C37 71 0 6.8p Cpar = 0
L37 71 72 300u
R37 72 73 0.17
C38 73 0 6.8p Cpar = 0
L38 73 74 300u
R38 74 75 0.17
C39 75 0 6.8p Cpar = 0
L39 75 76 300u
R39 76 77 0.17
C40 77 0 6.8p Cpar = 0
L40 77 78 300u
R40 78 79 0.17
C41 79 0 6.8p Cpar = 0
L41 79 80 300u
R41 80 81 0.17
C42 81 0 6.8p Cpar = 0
L42 81 82 300u
R42 82 83 0.17
C43 83 0 6.8p Cpar = 0
L43 83 84 300u
R43 84 85 0.17
C44 85 0 6.8p Cpar = 0
L44 85 86 300u
R44 86 87 0.17
C45 87 0 6.8p Cpar = 0
L45 87 88 300u
R45 88 89 0.17
C46 89 0 6.8p Cpar = 0
L46 89 90 300u
R46 90 91 0.17
C47 91 0 6.8p Cpar = 0
L47 91 92 300u
R47 92 93 0.17
C48 93 0 6.8p Cpar = 0
L48 93 94 300u
R48 94 95 0.17
C49 95 0 6.8p Cpar = 0
L49 95 96 300u
R49 96 97 0.17
C50 97 0 6.8p Cpar = 0
L50 97 98 300u
R50 98 99 0.17
C51 99 0 6.8p Cpar = 0
L51 99 100 300u
R51 100 101 0.17
C52 101 0 6.8p Cpar = 0
L52 101 102 300u
R52 102 103 0.17
C53 103 0 6.8p Cpar = 0
L53 103 104 300u
R53 104 105 0.17
C54 105 0 6.8p Cpar = 0
L54 105 106 300u
R54 106 107 0.17
C55 107 0 6.8p Cpar = 0
L55 107 108 300u
R55 108 109 0.17
C56 109 0 6.8p Cpar = 0
L56 109 110 300u
R56 110 111 0.17
C57 111 0 6.8p Cpar = 0
L57 111 112 300u
R57 112 113 0.17
C58 113 0 6.8p Cpar = 0
L58 113 114 300u
R58 114 115 0.17
C59 115 0 6.8p Cpar = 0
L59 115 116 300u
R59 116 117 0.17
C60 117 0 6.8p Cpar = 0
L60 117 118 300u
R60 118 119 0.17
C61 119 0 6.8p Cpar = 0
L61 119 120 300u
R61 120 121 0.17
C62 121 0 6.8p Cpar = 0
L62 121 122 300u
R62 122 123 0.17
C63 123 0 6.8p Cpar = 0
L63 123 124 300u
R63 124 125 0.17
C64 125 0 6.8p Cpar = 0
L64 125 126 300u
R64 126 127 0.17
C65 127 0 6.8p Cpar = 0
L65 127 128 300u
R65 128 -1 0.17
C66 -1 0 6.8p Cpar = 0
R66 -1 0 10k

.tran 30u
