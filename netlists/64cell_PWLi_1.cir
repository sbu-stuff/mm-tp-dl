*Auto-gererated 64-cell delay line circuit

I1 1 0 PWL file="C:\Users\zOob\Documents\SB REU\LTspice\data\PWL_Current_1.txt"
C2 1 0 6.8p Cpar = 0
L1 1 2 290n
R1 2 3 0.17
C3 3 0 6.8p Cpar = 0
L2 3 4 290n
R2 4 5 0.17
C4 5 0 6.8p Cpar = 0
L3 5 6 290n
R3 6 7 0.17
C5 7 0 6.8p Cpar = 0
L4 7 8 290n
R4 8 9 0.17
C6 9 0 6.8p Cpar = 0
L5 9 10 290n
R5 10 11 0.17
C7 11 0 6.8p Cpar = 0
L6 11 12 290n
R6 12 13 0.17
C8 13 0 6.8p Cpar = 0
L7 13 14 290n
R7 14 15 0.17
C9 15 0 6.8p Cpar = 0
L8 15 16 290n
R8 16 17 0.17
C10 17 0 6.8p Cpar = 0
L9 17 18 290n
R9 18 19 0.17
C11 19 0 6.8p Cpar = 0
L10 19 20 290n
R10 20 21 0.17
C12 21 0 6.8p Cpar = 0
L11 21 22 290n
R11 22 23 0.17
C13 23 0 6.8p Cpar = 0
L12 23 24 290n
R12 24 25 0.17
C14 25 0 6.8p Cpar = 0
L13 25 26 290n
R13 26 27 0.17
C15 27 0 6.8p Cpar = 0
L14 27 28 290n
R14 28 29 0.17
C16 29 0 6.8p Cpar = 0
L15 29 30 290n
R15 30 31 0.17
C17 31 0 6.8p Cpar = 0
L16 31 32 290n
R16 32 33 0.17
C18 33 0 6.8p Cpar = 0
L17 33 34 290n
R17 34 35 0.17
C19 35 0 6.8p Cpar = 0
L18 35 36 290n
R18 36 37 0.17
C20 37 0 6.8p Cpar = 0
L19 37 38 290n
R19 38 39 0.17
C21 39 0 6.8p Cpar = 0
L20 39 40 290n
R20 40 41 0.17
C22 41 0 6.8p Cpar = 0
L21 41 42 290n
R21 42 43 0.17
C23 43 0 6.8p Cpar = 0
L22 43 44 290n
R22 44 45 0.17
C24 45 0 6.8p Cpar = 0
L23 45 46 290n
R23 46 47 0.17
C25 47 0 6.8p Cpar = 0
L24 47 48 290n
R24 48 49 0.17
C26 49 0 6.8p Cpar = 0
L25 49 50 290n
R25 50 51 0.17
C27 51 0 6.8p Cpar = 0
L26 51 52 290n
R26 52 53 0.17
C28 53 0 6.8p Cpar = 0
L27 53 54 290n
R27 54 55 0.17
C29 55 0 6.8p Cpar = 0
L28 55 56 290n
R28 56 57 0.17
C30 57 0 6.8p Cpar = 0
L29 57 58 290n
R29 58 59 0.17
C31 59 0 6.8p Cpar = 0
L30 59 60 290n
R30 60 61 0.17
C32 61 0 6.8p Cpar = 0
L31 61 62 290n
R31 62 63 0.17
C33 63 0 6.8p Cpar = 0
L32 63 64 290n
R32 64 65 0.17
C34 65 0 6.8p Cpar = 0
L33 65 66 290n
R33 66 67 0.17
C35 67 0 6.8p Cpar = 0
L34 67 68 290n
R34 68 69 0.17
C36 69 0 6.8p Cpar = 0
L35 69 70 290n
R35 70 71 0.17
C37 71 0 6.8p Cpar = 0
L36 71 72 290n
R36 72 73 0.17
C38 73 0 6.8p Cpar = 0
L37 73 74 290n
R37 74 75 0.17
C39 75 0 6.8p Cpar = 0
L38 75 76 290n
R38 76 77 0.17
C40 77 0 6.8p Cpar = 0
L39 77 78 290n
R39 78 79 0.17
C41 79 0 6.8p Cpar = 0
L40 79 80 290n
R40 80 81 0.17
C42 81 0 6.8p Cpar = 0
L41 81 82 290n
R41 82 83 0.17
C43 83 0 6.8p Cpar = 0
L42 83 84 290n
R42 84 85 0.17
C44 85 0 6.8p Cpar = 0
L43 85 86 290n
R43 86 87 0.17
C45 87 0 6.8p Cpar = 0
L44 87 88 290n
R44 88 89 0.17
C46 89 0 6.8p Cpar = 0
L45 89 90 290n
R45 90 91 0.17
C47 91 0 6.8p Cpar = 0
L46 91 92 290n
R46 92 93 0.17
C48 93 0 6.8p Cpar = 0
L47 93 94 290n
R47 94 95 0.17
C49 95 0 6.8p Cpar = 0
L48 95 96 290n
R48 96 97 0.17
C50 97 0 6.8p Cpar = 0
L49 97 98 290n
R49 98 99 0.17
C51 99 0 6.8p Cpar = 0
L50 99 100 290n
R50 100 101 0.17
C52 101 0 6.8p Cpar = 0
L51 101 102 290n
R51 102 103 0.17
C53 103 0 6.8p Cpar = 0
L52 103 104 290n
R52 104 105 0.17
C54 105 0 6.8p Cpar = 0
L53 105 106 290n
R53 106 107 0.17
C55 107 0 6.8p Cpar = 0
L54 107 108 290n
R54 108 109 0.17
C56 109 0 6.8p Cpar = 0
L55 109 110 290n
R55 110 111 0.17
C57 111 0 6.8p Cpar = 0
L56 111 112 290n
R56 112 113 0.17
C58 113 0 6.8p Cpar = 0
L57 113 114 290n
R57 114 115 0.17
C59 115 0 6.8p Cpar = 0
L58 115 116 290n
R58 116 117 0.17
C60 117 0 6.8p Cpar = 0
L59 117 118 290n
R59 118 119 0.17
C61 119 0 6.8p Cpar = 0
L60 119 120 290n
R60 120 121 0.17
C62 121 0 6.8p Cpar = 0
L61 121 122 290n
R61 122 123 0.17
C63 123 0 6.8p Cpar = 0
L62 123 124 290n
R62 124 125 0.17
C64 125 0 6.8p Cpar = 0
L63 125 126 290n
R63 126 127 0.17
C65 127 0 6.8p Cpar = 0
L64 127 128 290n
R64 128 -1 0.17
C66 -1 0 6.8p Cpar = 0
R65 -1 0 220

.tran 500n
